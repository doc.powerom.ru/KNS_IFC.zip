Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:14:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:14:26 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{476E8102-9FE6-47FA-8399-F72BF3840816}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:14:25 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:14:25 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:14:25 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (14)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.16мм 50м | Главная модель
300 | Труба ПВХ гибкая гофр. д.16/20/25/32/40/50мм, лёгкая с протяжкой, 15/25/30/50/100м, цвет серый
300 | д.16мм 25м
300 | д.20мм 100м
300 | д.20мм 50м
300 | д.20мм 25м | Главная модель
300 | д.25мм 50м | Главная модель
300 | д.25мм 25м | Главная модель
300 | д.32мм 25м | Главная модель
300 | д.40мм 20м
300 | д.40мм 50м | Главная модель
300 | д.50мм 15м | Главная модель
300 | д.50мм 30м | Главная модель
300 | д.16мм 100м | Главная модель

# IfcDistributionPort (52)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_694177
2 x OutPort_694191
InPort_694183
InPort_694247
2 x OutPort_694261
InPort_694253
InPort_694313
2 x OutPort_694327
InPort_694319
InPort_694381
2 x OutPort_694395
InPort_694387
InPort_694449
2 x OutPort_694469
InPort_694455
InPort_694524
2 x OutPort_694544
InPort_694530
InPort_694604
2 x OutPort_694618
InPort_694610
InPort_694673
2 x OutPort_694687
InPort_694679
InPort_694741
2 x OutPort_694755
InPort_694747
InPort_694813
2 x OutPort_694833
InPort_694819
InPort_694896
2 x OutPort_694910
InPort_694902
InPort_694965
2 x OutPort_694985
InPort_694971
InPort_695039
2 x OutPort_695053
InPort_695045

# IfcFlowFitting: Неспецифицируемый_серый (13)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Серый
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Серый; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_серый; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_серый
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый
Размеры - Длина короба: 1 mm; Радиус загиба: 5 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_серый:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
694191 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø | Идентификация - Вариант конструкции: Главная модель
694261 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
694327 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø | Идентификация - Вариант конструкции: Главная модель
694395 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
694469 | 15.675 | 25 | 12.5 | 0.00000702465 | 7.4928 | 25 ммøx25 ммø
694544 | 23.175 | 40 | 20 | 0.000025385 | 10.5994 | 40 ммøx40 ммø | Идентификация - Вариант конструкции: Главная модель
694618 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
694687 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
694755 | 15.675 | 25 | 12.5 | 0.00000702465 | 7.4928 | 25 ммøx25 ммø
694833 | 19.175 | 32 | 16 | 0.0000137199 | 8.94255 | 32 ммøx32 ммø | Идентификация - Вариант конструкции: Главная модель
694910 | 23.175 | 40 | 20 | 0.000025385 | 10.5994 | 40 ммøx40 ммø
694985 | 28.175 | 50 | 25 | 0.0000473744 | 12.6705 | 50 ммøx50 ммø
695053 | 28.175 | 50 | 25 | 0.0000473744 | 12.6705 | 50 ммøx50 ммø | Идентификация - Вариант конструкции: Главная модель

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая с протяжкой 100м цвет серый (4)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая с протяжкой 100м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая с протяжкой 100м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая с протяжкой 100м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая с протяжкой 100м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16/20мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая с протяжкой 100м цвет серый
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Материал: DKC_ПВХ_Серый; ADSK_Наименование: Труба ПВХ гибкая гофр. д.16-20мм, лёгкая с протяжкой, 100м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.16-20мм, лёгкая с протяжкой, 100м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 91916
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая с протяжкой 100м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая с протяжкой 100м цвет серый:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm) | Вариант конструкции | sets with these values
694177 | 16 | 11.5 | 1994.37 | 16 ммø | 8 | -8
694183 | 16 | 11.5 | 614.371 | 16 ммø | 8 | -8 | Главная модель | 2
694247 | 20 | 14.9 | 1993.54 | 20 ммø | 10 | -10 | Главная модель | 2
694253 | 20 | 14.9 | 613.543 | 20 ммø | 10 | -10 | Главная модель | 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая с протяжкой 25м цвет серый (8)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая с протяжкой 25м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая с протяжкой 25м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая с протяжкой 25м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая с протяжкой 25м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16/20/25/32мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая с протяжкой 25м цвет серый
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Труба ПВХ гибкая гофр. д.16/20/25/32мм, лёгкая с протяжкой, 25м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.16/20/25/32мм, лёгкая с протяжкой, 25м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 9191625
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая с протяжкой 25м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая с протяжкой 25м цвет серый:...) | Вариант конструкции | sets with these values | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
694604 | Главная модель | 2 | 16 | 11.3 | 1994.37 | 16 ммø | 8 | -8
694610 |  |  | 16 | 11.3 | 614.371 | 16 ммø | 8 | -8
694673 |  |  | 20 | 14.7 | 1993.54 | 20 ммø | 10 | -10
694679 | Главная модель | 2 | 20 | 14.7 | 613.543 | 20 ммø | 10 | -10
694741 |  |  | 25 | 18.9 | 1992.51 | 25 ммø | 12.5 | -12.5
694747 | Главная модель | 2 | 25 | 18.9 | 612.507 | 25 ммø | 12.5 | -12.5
694813 | Главная модель | 2 | 32 | 24.6 | 1991.06 | 32 ммø | 16 | -16
694819 | Главная модель | 2 | 32 | 24.6 | 611.057 | 32 ммø | 16 | -16

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая с протяжкой 50м цвет серый (8)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая с протяжкой 50м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая с протяжкой 50м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая с протяжкой 50м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая с протяжкой 50м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16/20/25/40мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая с протяжкой 50м цвет серый
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Труба ПВХ гибкая гофр. д.16/20/25/40мм, лёгкая с протяжкой, 50м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.16/20/25/40мм, лёгкая с протяжкой, 50м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 9191650
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая с протяжкой 50м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая с протяжкой 50м цвет серый:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
694313 | 16 | 11.3 | 1994.37 | 16 ммø | 8 | -8
694319 | 16 | 11.3 | 614.371 | 16 ммø | 8 | -8 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
694381 | 20 | 14.7 | 1993.54 | 20 ммø | 10 | -10
694387 | 20 | 14.7 | 613.543 | 20 ммø | 10 | -10
694449 | 25 | 18.9 | 1992.51 | 25 ммø | 12.5 | -12.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
694455 | 25 | 18.9 | 612.507 | 25 ммø | 12.5 | -12.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
694524 | 40 | 31.5 | 1989.4 | 40 ммø | 20 | -20
694530 | 40 | 31.5 | 609.401 | 40 ммø | 20 | -20 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая с протяжкой 20м цвет серый (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая с протяжкой 20м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая с протяжкой 20м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая с протяжкой 20м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая с протяжкой 20м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 40 mm; Внутренний диаметр: 31.5 mm; Диаметр (Размер по каталогу): 40 mm; Размер: 40 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 20 mm; Нижняя отметка: -20 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.40мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая с протяжкой 20м цвет серый
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Труба ПВХ гибкая гофр. д40мм, лёгкая с протяжкой, 20м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.40мм, лёгкая с протяжкой, 20м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 91940
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая с протяжкой 20м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая с протяжкой 20м цвет серый:...) | Длина (mm)
694896 | 1989.4 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
694902 | 609.401

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 15м цвет серый (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Идентификация - Вариант конструкции: Главная модель; sets with these values: 2; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 15м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 15м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 15м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 15м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 15м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 50 mm; Внутренний диаметр: 40.1 mm; Диаметр (Размер по каталогу): 50 mm; Размер: 50 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 25 mm; Нижняя отметка: -25 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.50мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 15м цвет серый
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Труба ПВХ гибкая гофр. д50мм, лёгкая с протяжкой, 15м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.50мм, лёгкая с протяжкой, 15м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 91950
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 15м цвет серый:...) | Длина (mm)
694965 | 1987.33
694971 | 607.33

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 30м цвет серый (2)
In: Этаж 01
Электросети - Стандартное: Стандартные типы коробов: ПВХ д.50мм; Верхняя отметка: 25 mm; Нижняя отметка: -25 mm; sets with these values: 2
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 30м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 30м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 30м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 30м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 50 mm; Внутренний диаметр: 40.1 mm; Диаметр (Размер по каталогу): 50 mm; Размер: 50 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 30м цвет серый
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Труба ПВХ гибкая гофр. д50мм, лёгкая с протяжкой, 30м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.50мм, лёгкая с протяжкой, 30м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 9195030
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 30м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая с протяжкой 30м цвет серый:...) | Длина (mm)
695039 | 1987.33
695045 | 607.33
