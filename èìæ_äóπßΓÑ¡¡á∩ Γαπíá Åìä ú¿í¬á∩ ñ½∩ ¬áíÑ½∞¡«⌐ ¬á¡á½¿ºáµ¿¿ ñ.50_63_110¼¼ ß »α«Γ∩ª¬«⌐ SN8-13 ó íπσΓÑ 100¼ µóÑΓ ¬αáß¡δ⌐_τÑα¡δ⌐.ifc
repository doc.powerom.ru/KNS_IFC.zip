Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T17:05:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 17:05:27 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{A87B7B29-9D46-46E2-9E97-E1AA306B8BF3}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 17:05:26 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 17:05:26 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 17:05:26 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (4)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.50мм
300 | д.63мм
300 | д.110мм
300 | Двустенная труба ПНД гибкая для кабельной канализации, д.50/63/110мм с протяжкой, SN8-13, в бухте 100м, цвет красный/черный

# IfcDistributionPort (24)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_639899
2 x OutPort_639901
InPort_639900
InPort_639903
2 x OutPort_639905
InPort_639904
InPort_639907
2 x OutPort_639909
InPort_639908
InPort_640309
2 x OutPort_640311
InPort_640310
InPort_640313
2 x OutPort_640315
InPort_640314
InPort_640317
2 x OutPort_640319
InPort_640318

# IfcFlowFitting: Неспецифицируемый_красный (3)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Красный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Красный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_красный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_красный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный
Размеры - Длина короба: 1 mm; Радиус загиба: 10 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_красный:...) | Вариант конструкции | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
639901 | Главная модель | 28.175 | 50 | 25 | 0.0000473744 | 12.6705 | 50 ммøx50 ммø
639905 |  | 34.675 | 63 | 31.5 | 0.0000911247 | 15.3629 | 63 ммøx63 ммø
639909 | Главная модель | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø

# IfcFlowFitting: Неспецифицируемый_черный (3)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Черный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Черный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_черный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_черный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Размеры - Угол: 45 deg; Длина короба: 1 mm; Радиус загиба: 10 mm
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_черный:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
640311 | 28.175 | 50 | 25 | 0.0000473744 | 12.6705 | 50 ммøx50 ммø
640315 | 34.675 | 63 | 31.5 | 0.0000911247 | 15.3629 | 63 ммøx63 ммø | Идентификация - Вариант конструкции: Главная модель
640319 | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет красный (6)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет красный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет красный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет красный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет красный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая для кабельной канализации в бухте 100м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет красный
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-015-47022248-2006; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Красный; ADSK_Наименование: Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой, SN8-13, в бухте 100м, цвет красный; ADSK_Наименование краткое: Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой, SN8-13, в бухте 100м, цвет красный; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кол-во в бухте L_м: д.50 SN13=100 /д.63 SN13=100 / д.110 SN8=100; DKC_Кольцевая жесткость_кПа: д.50 SN13=13 /д.63 SN13=13 / д.110 SN8=8; DKC_Минимальный радиус изгиба (количество диаметров): 8; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –25 до + 90 °С; DKC_Температура эксплуатации: от –55 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или при монолитном бетоностроении); Тип трубопровода: 121950
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/88/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет красный; Комментарии к типоразмеру: Гибкие двустенные гофрированные трубы (красные/черные (А))
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет красный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
639899 | 50 | 41.5 | 1987.33 | 50 ммø | 25 | -25
639900 | 50 | 41.5 | 987.33 | 50 ммø | 25 | -25 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
639903 | 63 | 51.5 | 1984.64 | 63 ммø | 31.5 | -31.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
639904 | 63 | 51.5 | 984.637 | 63 ммø | 31.5 | -31.5
639907 | 110 | 94 | 1974.9 | 110 ммø | 55 | -55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
639908 | 110 | 94 | 974.903 | 110 ммø | 55 | -55

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет черный (6)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет черный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет черный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет черный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая для кабельной канализации в бухте 100м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет черный
Соединительные детали - Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-015-47022248-2006; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Наименование: Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой, SN8-13, в бухте 100м, цвет черный; ADSK_Наименование краткое: Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой, SN8-13, в бухте 100м, цвет черный; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кол-во в бухте L_м: д.50 SN13=100 /д.63 SN13=100 / д.110 SN8=100; DKC_Кольцевая жесткость_кПа: д.50 SN13=13 /д.63 SN13=13 / д.110 SN8=8; DKC_Минимальный радиус изгиба (количество диаметров): 8; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –25 до + 90 °С; DKC_Температура эксплуатации: от –55 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или при монолитном бетоностроении); Тип трубопровода: 121952
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/88/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет черный; Комментарии к типоразмеру: Гибкие двустенные гофрированные трубы (красные/черные (А))
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.50/63/110мм с протяжкой SN8-13 в бухте 100м цвет черный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
640309 | 50 | 41.5 | 1987.33 | 50 ммø | 25 | -25 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
640310 | 50 | 41.5 | 987.33 | 50 ммø | 25 | -25
640313 | 63 | 51.5 | 1984.64 | 63 ммø | 31.5 | -31.5
640314 | 63 | 51.5 | 984.637 | 63 ммø | 31.5 | -31.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
640317 | 110 | 94 | 1974.9 | 110 ммø | 55 | -55
640318 | 110 | 94 | 974.903 | 110 ммø | 55 | -55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
