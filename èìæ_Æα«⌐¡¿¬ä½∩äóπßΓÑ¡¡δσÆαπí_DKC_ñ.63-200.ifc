Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:02:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:02:28 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{3054352F-145E-49C4-B518-CEE225DC7EC3}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:02:26 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:02:27 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:02:27 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (18)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
2 x 300 | д.63мм
300 | д.75мм | Главная модель
300 | д.90мм
300 | д.110мм | Главная модель
300 | д.125мм | Главная модель
2 x 300 | д.140мм | Главная модель
300 | д.160мм
300 | д.200мм | Главная модель
300 | д.75мм
300 | д.90мм | Главная модель
300 | д.110мм
300 | д.125мм
300 | д.160мм | Главная модель
300 | д.200мм
300 | Тройник 90° | Главная модель
300 | Тройник 45° | Главная модель

# IfcFlowFitting: Кольцо резиновое уплотнительное (48)
In: Этаж 01
Type - Material: DKC_Резина
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Резина; DKC_Степень защиты: IP 55 с аксессуарами; DKC_Температура эксплуатации: от –25 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Кольцо резиновое уплотнительное; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: герметизация мест соединения гибких, жестких, дренажных гофрированных двустенных труб с соединительными муфтами, заглушками, разветвителями, переходниками
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Кольцо резиновое уплотнительное
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no
Прочее - Код типа: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Семейство: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Семейство и типоразмер: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Тип: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное
Стадии - Стадия возведения: Стадия 1
Name (КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200:Кольцо резиновое уплотнительное:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | A (mm) | DN (mm) | Dвнеш (mm) | Dвнут (mm) | Объем (m3) | ADSK_Масса | Вариант конструкции
606073 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004
606075 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004
606077 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004 | Главная модель
606079 | 016075 | Кольцо резиновое уплотнительное для двустенной трубы 75мм | 2 | 75 | 74.6 | 60.4 | 0.00000301107 | 0.007
606081 | 016075 | Кольцо резиновое уплотнительное для двустенной трубы 75мм | 2 | 75 | 74.6 | 60.4 | 0.00000301107 | 0.007
606083 | 016075 | Кольцо резиновое уплотнительное для двустенной трубы 75мм | 2 | 75 | 74.6 | 60.4 | 0.00000301107 | 0.007 | Главная модель
606085 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009
606087 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009 | Главная модель
606089 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009 | Главная модель
606091 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
606093 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
606095 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
606097 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016
606099 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016 | Главная модель
606101 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016 | Главная модель
606103 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019 | Главная модель
606105 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019 | Главная модель
606107 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019 | Главная модель
606109 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031
606111 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Главная модель
606113 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Главная модель
606115 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06 | Главная модель
606117 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06 | Главная модель
606119 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06 | Главная модель
608602 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004 | Главная модель
608604 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004
608606 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004
608608 | 016075 | Кольцо резиновое уплотнительное для двустенной трубы 75мм | 2 | 75 | 74.6 | 60.4 | 0.00000301107 | 0.007
608610 | 016075 | Кольцо резиновое уплотнительное для двустенной трубы 75мм | 2 | 75 | 74.6 | 60.4 | 0.00000301107 | 0.007
608612 | 016075 | Кольцо резиновое уплотнительное для двустенной трубы 75мм | 2 | 75 | 74.6 | 60.4 | 0.00000301107 | 0.007
608614 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009
608616 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009
608618 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009 | Главная модель
608620 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
608622 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
608624 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015 | Главная модель
608626 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016
608628 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016 | Главная модель
608630 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016 | Главная модель
608632 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019
608634 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019 | Главная модель
608636 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019
608638 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Главная модель
608640 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Главная модель
608642 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Главная модель
608644 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06 | Главная модель
608646 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06 | Главная модель
608648 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06

# IfcFlowFitting: Тройник (16)
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Оранжевый
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Пластик_Полипропилен_Оранжевый; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: Тройник; Описание: Назначение: механическое неразъемное соединение гибких, жестких, дренажных гофрированных двустенных труб одного диаметра
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Тройник
Видимость - DKC_Уплотнительные резиновые кольца: yes
Графика - Использовать масштаб аннотаций: no
Данные - DKC_Степень защиты: IP 55
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник; Семейство: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник; Семейство и типоразмер: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник; Тип: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Стадии - Стадия возведения: Стадия 1
Name (КНС_ТройникДляДвустенныхТруб_DKC_д.63-200:Тройник:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | D1 (mm) | D2 (mm) | D2половина (mm) | D3 (mm) | D4 (mm) | D4половина (mm) | D4половина-L (mm) | DN (mm) | L (mm) | L1 (mm) | L2 (mm) | L-D4половина (mm) | Объем (m3) | Размер | Угол (deg) = Угол1 (deg) | ADSK_Масса | Вариант конструкции
588259 | 020063 | Тройник для двустенных труб, 90 град., полипропилен, д.63мм | 57 | 59 | 29.5 | 64 | 70 | 35 | -49 | 63 | 84 | 176 | 119 | 49 | 0.000720354 | 63 ммøx63 ммøx63 ммø | 90 | 0.171
589983 | 020075 | Тройник для двустенных труб, 90 град., полипропилен, д.75мм | 70 | 71 | 35.5 | 77 | 86 | 43 | -52 | 75 | 95 | 208 | 138 | 52 | 0.00123934 | 75 ммøx75 ммøx75 ммø | 90 | 0.142 | Главная модель
590031 | 020090 | Тройник для двустенных труб, 90 град., полипропилен, д.90мм | 91 | 91 | 45.5 | 91 | 93 | 46.5 | -87 | 90 | 133.5 | 242 | 180 | 87 | 0.00221784 | 90 ммøx90 ммøx90 ммø | 90 | 0.22 | Главная модель
590046 | 020110 | Тройник для двустенных труб, 90 град., полипропилен, д.110мм | 103 | 106 | 53 | 111 | 115 | 57.5 | -65 | 110 | 122.5 | 248 | 180 | 65 | 0.00305207 | 110 ммøx110 ммøx110 ммø | 90 | 0.45 | Главная модель
590061 | 020125 | Тройник для двустенных труб, 90 град., полипропилен, д.125мм | 118 | 121 | 60.5 | 126 | 128 | 64 | -66 | 125 | 130 | 255 | 194 | 66 | 0.00401164 | 125 ммøx125 ммøx125 ммø | 90 | 0.63 | Главная модель
590076 | 020140 | Тройник для двустенных труб, 90 град., полипропилен, д.140мм | 133 | 136 | 68 | 141 | 145 | 72.5 | -75 | 140 | 147.5 | 270 | 220 | 75 | 0.00551418 | 140 ммøx140 ммøx140 ммø | 90 | 0.701 | Главная модель
590091 | 020160 | Тройник для двустенных труб, 90 град., полипропилен, д.160мм | 153 | 156 | 78 | 161 | 166 | 83 | -99 | 160 | 182 | 353 | 265 | 99 | 0.00937961 | 160 ммøx160 ммøx160 ммø | 90 | 0.82 | Главная модель
590106 | 020200 | Тройник для двустенных труб, 90 град., полипропилен, д.200мм | 189 | 193 | 96.5 | 201 | 206 | 103 | -119 | 200 | 222 | 405 | 325 | 119 | 0.0167852 | 200 ммøx200 ммøx200 ммø | 90 | 1.805 | Главная модель
608585 | 019063 | Тройник для двустенных труб, 45 град., полипропилен, д.63мм | 57 | 59 | 29.5 | 64 | 68 | 34 | -82.0833 | 63 | 116.083 | 172 | 87 | 82.0833 | 0.000751807 | 63 ммøx63 ммøx63 ммø | 45 | 0.3
608588 | 019075 | Тройник для двустенных труб, 45 град., полипропилен, д.75мм | 70 | 71 | 35.5 | 77 | 80 | 40 | -96.5685 | 75 | 136.569 | 233 | 122 | 96.5685 | 0.0013798 | 75 ммøx75 ммøx75 ммø | 45 | 0.16 | Главная модель
608590 | 019090 | Тройник для двустенных труб, 45 град., полипропилен, д.90мм | 84 | 86 | 43 | 93 | 100 | 50 | -120.711 | 90 | 170.711 | 255 | 136 | 120.711 | 0.00237747 | 90 ммøx90 ммøx90 ммø | 45 | 0.23 | Главная модель
608592 | 019110 | Тройник для двустенных труб, 45 град., полипропилен, д.110мм | 103 | 105 | 52.5 | 111 | 113 | 56.5 | -136.403 | 110 | 192.903 | 270 | 150 | 136.403 | 0.00361723 | 110 ммøx110 ммøx110 ммø | 45 | 0.562
608594 | 019125 | Тройник для двустенных труб, 45 град., полипропилен, д.125мм | 118 | 121 | 60.5 | 126 | 129 | 64.5 | -155.717 | 125 | 220.217 | 325 | 176 | 155.717 | 0.00563678 | 125 ммøx125 ммøx125 ммø | 45 | 0.83 | Главная модель
608596 | 019140 | Тройник для двустенных труб, 45 град., полипропилен, д.140мм | 133 | 136 | 68 | 141 | 145 | 72.5 | -175.03 | 140 | 247.53 | 370 | 200 | 175.03 | 0.00807266 | 140 ммøx140 ммøx140 ммø | 45 | 1.08 | Главная модель
608598 | 019160 | Тройник для двустенных труб, 45 град., полипропилен, д.160мм | 153 | 155 | 77.5 | 161 | 166 | 83 | -200.38 | 160 | 283.38 | 396 | 220 | 200.38 | 0.0115239 | 160 ммøx160 ммøx160 ммø | 45 | 1.23 | Главная модель
608600 | 019200 | Тройник для двустенных труб, 45 град., полипропилен, д.200мм | 189 | 196 | 98 | 201 | 208 | 104 | -251.078 | 200 | 355.078 | 480 | 275 | 251.078 | 0.0224376 | 200 ммøx200 ммøx200 ммø | 45 | 2.15 | Главная модель
