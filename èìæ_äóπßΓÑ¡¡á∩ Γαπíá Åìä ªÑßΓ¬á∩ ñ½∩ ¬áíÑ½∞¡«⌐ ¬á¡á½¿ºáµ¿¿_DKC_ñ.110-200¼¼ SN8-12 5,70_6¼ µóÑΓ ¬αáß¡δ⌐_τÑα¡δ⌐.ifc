Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T16:07:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 16:07:42 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9983116B-0BF9-4330-B0D7-2829800D5F3A}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 16:07:40 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 16:07:41 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 16:07:41 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (9)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.110мм 6м | Лого (основной)
300 | д.125мм 6м | Лого (основной)
300 | д.160мм 6м | Лого (основной)
300 | д.200мм 6м | Лого : Лого
300 | Двустенная труба ПНД жесткая для кабельной канализации, д.110-200мм, SN8-12, 5,70/6м, цвет красный/черный | Лого : Лого
300 | д.110мм 5,70м | Главная модель
300 | д.125мм 5,70м | Главная модель
300 | д.160мм 5,70м
300 | д.200мм 5,70м | Главная модель

# IfcBuildingElementProxy: Текст модели:600 мм Arial
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 600 мм Arial
Графика - Горизонтальное выравнивание: Влево; Текст: ЖЕСТКИЕ ДВУСТЕННЫЕ ГОФРИРОВАННЫЕ ТРУБЫ
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Вариант конструкции: Лого : Лого; Подкатегория: Обобщенные модели; Имя типа: 600 мм Arial
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 600 мм Arial; Семейство: Текст модели: 600 мм Arial; Семейство и типоразмер: Текст модели: 600 мм Arial; Тип: Текст модели: 600 мм Arial; Имя семейства: Текст модели
Размеры - Глубина:: 50 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 600 mm; Шрифт текста: Arial

# IfcDistributionPort (64)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_524252
2 x OutPort_524254
InPort_524253
InPort_524257
2 x OutPort_524259
InPort_524258
InPort_524262
2 x OutPort_524264
InPort_524263
InPort_524267
2 x OutPort_524269
InPort_524268
InPort_563691
2 x OutPort_563693
InPort_563692
InPort_563695
2 x OutPort_563697
InPort_563696
InPort_563699
2 x OutPort_563701
InPort_563700
InPort_563703
2 x OutPort_563705
InPort_563704
InPort_563901
2 x OutPort_563903
InPort_563902
InPort_563905
2 x OutPort_563907
InPort_563906
InPort_563909
2 x OutPort_563911
InPort_563910
InPort_563913
2 x OutPort_563915
InPort_563914
InPort_563941
2 x OutPort_563943
InPort_563942
InPort_563945
2 x OutPort_563947
InPort_563946
InPort_563949
2 x OutPort_563951
InPort_563950
InPort_563953
2 x OutPort_563955
InPort_563954

# IfcFlowFitting: Неспецифицируемый_красный (8)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Красный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Красный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_красный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_красный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный
Размеры - Длина короба: 1 mm; Радиус загиба: 10 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_красный:...) | Вариант конструкции | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
524254 | Главная модель | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø
524259 | Главная модель | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø
524264 | Главная модель | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø
524269 | Главная модель | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø
563903 |  | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø
563907 | Главная модель | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø
563911 | Главная модель | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø
563915 | Главная модель | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø

# IfcFlowFitting: Неспецифицируемый_черный (8)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Черный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Черный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_черный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_черный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Размеры - Угол: 45 deg; Длина короба: 1 mm; Радиус загиба: 10 mm
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_черный:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
563693 | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø | Идентификация - Вариант конструкции: Главная модель
563697 | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø
563701 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø
563705 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø
563943 | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø
563947 | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø
563951 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø
563955 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø | Идентификация - Вариант конструкции: Главная модель

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет красный (8)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет красный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет красный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет красный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет красный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД жесткая для кабельной канализации SN8-12
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет красный
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Красный; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-019-47022248-2008; ADSK_Наименование: Двустенная труба ПНД жесткая для кабельной канализации, д.110-200мм, SN8-12, 5,70м, цвет красный; ADSK_Наименование краткое: Двустенная труба ПНД жесткая для кабельной канализации, д.110-200мм, SN8-12, 5,70м, цвет красный; DKC_Длина отрезков L_м: 5.7; DKC_Исполнение: Исполнение 2 – специальное исполнение для контейнерной отправки. Длина отрезков трубы 5,70 м, соединительная муфта одета на торец трубы; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кольцевая жесткость_кПа: д.110 SN12=12 / д.125 SN10=10 / д.160 SN8=8 / д.200 SN8=8; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –40 до + 90 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или замоноличено внутри бетонных (ж/б) изделий). Рекомендуется использовать на участках с высокой нагрузкой (под автомобильными и ж/д дорогами и т. п.), при блочной укладке труб, при укладке в трубах тяжелого кабеля.; Тип трубопровода: 160915
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/188/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет красный; Комментарии к типоразмеру: Жесткие двустенные гофрированные трубы
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет красный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
563901 | 110 | 94 | 1974.9 | 110 ммø | 55 | -55
563902 | 110 | 94 | 974.903 | 110 ммø | 55 | -55
563905 | 125 | 107 | 1971.8 | 125 ммø | 62.5 | -62.5
563906 | 125 | 107 | 971.797 | 125 ммø | 62.5 | -62.5
563909 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
563910 | 160 | 137 | 964.548 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
563913 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
563914 | 200 | 172 | 956.264 | 200 ммø | 100 | -100 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет черный (8)
In: Этаж 01
Электросети - Стандартное: Стандартные типы коробов: ПНД жесткая для кабельной канализации SN8-12; sets with these values: 2
Соединительные детали - Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Прочее - Категория: Короба; Имя семейства: Короб без соединительных деталей; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет черный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет черный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет черный; sets with these values: 2
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/188/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет черный; Комментарии к типоразмеру: Жесткие двустенные гофрированные трубы
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет черный
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-019-47022248-2008; ADSK_Наименование: Двустенная труба ПНД жесткая для кабельной канализации, д.110-200мм, SN8-12, 5,70м, цвет черный; ADSK_Наименование краткое: Двустенная труба ПНД жесткая для кабельной канализации, д.110-200мм, SN8-12, 5,70м, цвет черный; DKC_Длина отрезков L_м: 5.7; DKC_Исполнение: Исполнение 2 – специальное исполнение для контейнерной отправки. Длина отрезков трубы 5,70 м, соединительная муфта одета на торец трубы; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кольцевая жесткость_кПа: д.110 SN12=12 / д.125 SN10=10 / д.160 SN8=8 / д.200 SN8=8; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –40 до + 90 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или замоноличено внутри бетонных (ж/б) изделий). Рекомендуется использовать на участках с высокой нагрузкой (под автомобильными и ж/д дорогами и т. п.), при блочной укладке труб, при укладке в трубах тяжелого кабеля.; Тип трубопровода: 160917
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 5,70м цвет черный:...) | Вариант конструкции | sets with these values | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
563941 | Главная модель | 2 | 110 | 94 | 1974.9 | 110 ммø | 55 | -55
563942 | Главная модель | 2 | 110 | 94 | 974.903 | 110 ммø | 55 | -55
563945 |  |  | 125 | 107 | 1971.8 | 125 ммø | 62.5 | -62.5
563946 | Главная модель | 2 | 125 | 107 | 971.797 | 125 ммø | 62.5 | -62.5
563949 | Главная модель | 2 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80
563950 | Главная модель | 2 | 160 | 137 | 964.548 | 160 ммø | 80 | -80
563953 | Главная модель | 2 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
563954 | Главная модель | 2 | 200 | 172 | 956.264 | 200 ммø | 100 | -100

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет красный (8)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет красный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет красный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет красный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет красный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД жесткая для кабельной канализации SN8-12
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет красный
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-019-47022248-2008; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Красный; ADSK_Наименование: Двустенная труба ПНД жесткая для кабельной канализации, д.110-200мм, SN8-12, 6м, цвет красный; ADSK_Наименование краткое: Двустенная труба ПНД жесткая для кабельной канализации, д.110-200мм, SN8-12, 6м, цвет красный; DKC_Длина отрезков L_м: 6; DKC_Исполнение: Исполнение 1 – стандартное исполнение отрезков трубы по 6 м, соединительная муфта одета на торец отрезка трубы; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кольцевая жесткость_кПа: д.110 SN12=12 / д.125 SN10=10 / д.160 SN8=8 / д.200 SN8=8; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –40 до + 90 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или замоноличено внутри бетонных (ж/б) изделий). Рекомендуется использовать на участках с высокой нагрузкой (под автомобильными и ж/д дорогами и т. п.), при блочной укладке труб, при укладке в трубах тяжелого кабеля.; Тип трубопровода: 160911
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/188/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет красный; Комментарии к типоразмеру: Жесткие двустенные гофрированные трубы
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет красный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
524252 | 110 | 94 | 1974.9 | 110 ммø | 55 | -55
524253 | 110 | 94 | 974.903 | 110 ммø | 55 | -55
524257 | 125 | 107 | 1971.8 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
524258 | 125 | 107 | 971.797 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
524262 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80
524263 | 160 | 137 | 964.548 | 160 ммø | 80 | -80
524267 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
524268 | 200 | 172 | 956.264 | 200 ммø | 100 | -100 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет черный (8)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет черный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет черный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет черный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД жесткая для кабельной канализации SN8-12
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет черный
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-019-47022248-2008; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Наименование: Двустенная труба ПНД жесткая для кабельной канализации, д.110-200мм, SN8-12, 6м, цвет черный; ADSK_Наименование краткое: Двустенная труба ПНД жесткая для кабельной канализации, д.110-200мм, SN8-12, 6м, цвет черный; DKC_Длина отрезков L_м: 6; DKC_Исполнение: Исполнение 1 – стандартное исполнение отрезков трубы по 6 м, соединительная муфта одета на торец отрезка трубы; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кольцевая жесткость_кПа: д.110 SN12=12 / д.125 SN10=10 / д.160 SN8=8 / д.200 SN8=8; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –40 до + 90 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или замоноличено внутри бетонных (ж/б) изделий). Рекомендуется использовать на участках с высокой нагрузкой (под автомобильными и ж/д дорогами и т. п.), при блочной укладке труб, при укладке в трубах тяжелого кабеля.; Тип трубопровода: 160913
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/188/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет черный; Комментарии к типоразмеру: Жесткие двустенные гофрированные трубы
Соединительные детали - Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.110-200мм SN8-12 6м цвет черный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
563691 | 110 | 94 | 1974.9 | 110 ммø | 55 | -55
563692 | 110 | 94 | 974.903 | 110 ммø | 55 | -55
563695 | 125 | 107 | 1971.8 | 125 ммø | 62.5 | -62.5
563696 | 125 | 107 | 971.797 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
563699 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80
563700 | 160 | 137 | 964.548 | 160 ммø | 80 | -80
563703 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
563704 | 200 | 172 | 956.264 | 200 ммø | 100 | -100
