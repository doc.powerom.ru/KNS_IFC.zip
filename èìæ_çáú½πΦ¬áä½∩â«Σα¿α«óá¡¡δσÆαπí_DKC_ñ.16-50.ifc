Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:05:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:05:01 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{D1DFF3AA-7601-46E9-963C-3F8A66DD05A2}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:05:01 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:05:01 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:05:01 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (7)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.16мм | Главная модель
300 | д.20мм | Главная модель
300 | д.25мм
300 | д.32мм | Главная модель
300 | д.40мм
300 | д.50мм | Главная модель
300 | Муфта | Главная модель

# IfcFlowFitting: Заглушка (6)
In: Этаж 01
Type - Material: DKC_Полиэтилен_Прозрачный
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Полиэтилен_Прозрачный; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Заглушка; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: защита концов гофрированных и жестких гладких труб от попадания строительного мусора, способного помешать дальнейшей протяжке кабеля
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ЗаглушкаДляГофрированныхТруб_DKC_д.16-50
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Заглушка
Графика - Использовать масштаб аннотаций: no
Данные - DKC_Степень защиты: IP 40
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_ЗаглушкаДляГофрированныхТруб_DKC_д.16-50: Заглушка; Семейство: КНС_ЗаглушкаДляГофрированныхТруб_DKC_д.16-50: Заглушка; Семейство и типоразмер: КНС_ЗаглушкаДляГофрированныхТруб_DKC_д.16-50: Заглушка; Тип: КНС_ЗаглушкаДляГофрированныхТруб_DKC_д.16-50: Заглушка
Размеры - H: 10 mm; L: 11 mm
Стадии - Стадия возведения: Стадия 1
Name (КНС_ЗаглушкаДляГофрированныхТруб_DKC_д.16-50:Заглушка:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | A (mm) | D (mm) | DN (mm) | Объем (m3) | Размер | ADSK_Масса
700976 | 50916 | Заглушка для труб, IP40, д.16мм | 17 | 20 | 16 | 5.67055e-07 | 16 ммø | 0.001 | Идентификация - Вариант конструкции: Главная модель
701036 | 50920 | Заглушка для труб, IP40, д.20мм | 21 | 25 | 20 | 8.07639e-07 | 20 ммø | 0.001
701045 | 50925 | Заглушка для труб, IP40, д.25мм | 26 | 30 | 25 | 0.00000110354 | 25 ммø | 0.002
701054 | 50932 | Заглушка для труб, IP40, д.32мм | 33 | 38 | 32 | 0.00000163887 | 32 ммø | 0.002
701063 | 50940 | Заглушка для труб, IP40, д.40мм | 41 | 45 | 40 | 0.00000222209 | 40 ммø | 0.004
701072 | 50950 | Заглушка для труб, IP40, д.50мм | 51 | 55 | 50 | 0.00000316452 | 50 ммø | 0.005 | Идентификация - Вариант конструкции: Главная модель
