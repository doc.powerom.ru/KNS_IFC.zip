Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:08:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:08:28 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{AEC7B205-E0D0-4038-A421-D69B7CDC800F}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:08:27 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:08:27 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:08:27 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes; Имя типа: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300 (2)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | D71х49
300 | Корпус коробки для заливки в бетон

# IfcFlowFitting: D71х49, КНС_КорпусКоробкиДляЗаливкиВБетон_DKC_D70х57:D71х49:758598
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Синий
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59381B; ADSK_Материал: DKC_Пластик_Полипропилен_Синий; ADSK_Наименование: Корпус коробки для заливки в бетон, д.71х49мм
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59381B/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: D71х49; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: увеличение глубины установочных коробок и коробок потолочных для заливки в бетон
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КорпусКоробкиДляЗаливкиВБетон_DKC_D70х57
Type - Текст - ADSK_Масса: 0.023
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D71х49
Данные - ADSK_Наименование краткое: Корпус коробки для заливки в бетон, д.71х49мм
Зависимости - Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_КорпусКоробкиДляЗаливкиВБетон_DKC_D70х57: D71х49; Семейство: КНС_КорпусКоробкиДляЗаливкиВБетон_DKC_D70х57: D71х49; Семейство и типоразмер: КНС_КорпусКоробкиДляЗаливкиВБетон_DKC_D70х57: D71х49; Тип: КНС_КорпусКоробкиДляЗаливкиВБетон_DKC_D70х57: D71х49
Размеры - Объем: 0.0000318148 m3; Площадь: 0.013419 m2
Стадии - Стадия возведения: Стадия 1
