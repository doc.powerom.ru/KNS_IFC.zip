Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:00:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:00:04 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{10C4ED07-B8EB-4A02-9669-E0157D232ECA}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:00:03 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:00:03 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:00:03 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (7)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.90мм
300 | д.110мм
300 | д.125мм | Главная модель
300 | д.160мм | Главная модель
300 | д.63мм
300 | д.50мм | Главная модель
300 | Тройной | Главная модель

# IfcFlowFitting: д.110мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160:д.110мм:562692
In: Этаж 01
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025113; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.110мм, тройной; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.110мм, тройной; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025113/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.110мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160
Type - Размеры - H: 142 mm; L1: 428 mm; L1half: 214 mm; L3: 142 mm; R: 56 mm; S: 25 mm
Type - Текст - ADSK_Масса: 0.195
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.110мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.110мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.110мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.110мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.110мм
Размеры - Объем: 0.000780532 m3; Площадь: 0.0502685 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.125мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160:д.125мм:562694
In: Этаж 01
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025123; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.125мм, тройной; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.125мм, тройной; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025123/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.125мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160
Type - Размеры - H: 140 mm; L1: 490 mm; L1half: 245 mm; L3: 164 mm; R: 63 mm; S: 25 mm
Type - Текст - ADSK_Масса: 0.197
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.125мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.125мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.125мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.125мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.125мм
Размеры - Объем: 0.000779871 m3; Площадь: 0.052342 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.160мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160:д.160мм:562696
In: Этаж 01
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025163; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.160мм, тройной; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.160мм, тройной; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025163/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.160мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160
Type - Размеры - H: 175 mm; L1: 602 mm; L1half: 301 mm; L3: 200 mm; R: 82 mm; S: 30 mm
Type - Текст - ADSK_Масса: 0.33
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.160мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.160мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.160мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.160мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.160мм
Размеры - Объем: 0.00125942 m3; Площадь: 0.0737211 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.50мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160:д.50мм:563622
In: Этаж 01
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025050; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.50мм, тройной; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.50мм, тройной; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025050/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.50мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160
Type - Размеры - H: 60 mm; L1: 204 mm; L1half: 102 mm; L3: 65 mm; R: 22.5 mm; S: 20 mm
Type - Текст - ADSK_Масса: 0.07
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.50мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.50мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.50мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.50мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.50мм
Размеры - Объем: 0.000149379 m3; Площадь: 0.0142905 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.63мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160:д.63мм:563611
In: Этаж 01
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025063; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.63мм, тройной; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.63мм, тройной; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025063/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.63мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160
Type - Размеры - H: 76 mm; L1: 248 mm; L1half: 124 mm; L3: 80 mm; R: 32 mm; S: 20 mm
Type - Текст - ADSK_Масса: 0.06
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.63мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.63мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.63мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.63мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.63мм
Размеры - Объем: 0.00018395 m3; Площадь: 0.0178701 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.90мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160:д.90мм:562690
In: Этаж 01
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025903; ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.90мм, тройной; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.90мм, тройной; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025903/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.90мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160
Type - Размеры - H: 100 mm; L1: 362 mm; L1half: 181 mm; L3: 124 mm; R: 46 mm; S: 25 mm
Type - Текст - ADSK_Масса: 0.26
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.90мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.90мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.90мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.90мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубТройной_DKC_д.50-160: д.90мм
Размеры - Объем: 0.000406453 m3; Площадь: 0.0317483 m2
Стадии - Стадия возведения: Стадия 1
