Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:15:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:15:41 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{DC693C43-0A5E-4CA2-B278-B85B4B3D2D81}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:15:40 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:15:40 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:15:40 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (14)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.16мм 50м
300 | Труба ПВХ гибкая гофр. д.16/20/25/32/40/50мм, лёгкая без протяжки, 15/25/30/50/100м, цвет серый
300 | д.16мм 25м
300 | д.20мм 100м | Идентификация - Вариант конструкции: Главная модель
300 | д.20мм 50м
300 | д.20мм 25м | Идентификация - Вариант конструкции: Главная модель
300 | д.25мм 50м
300 | д.25мм 25м | Идентификация - Вариант конструкции: Главная модель
300 | д.32мм 25м
300 | д.40мм 20м | Идентификация - Вариант конструкции: Главная модель
300 | д.40мм 50м | Идентификация - Вариант конструкции: Главная модель
300 | д.50мм 15м
300 | д.50мм 30м
300 | д.16мм 100м

# IfcDistributionPort (52)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_694213
2 x OutPort_694227
InPort_694219
InPort_694281
2 x OutPort_694293
InPort_694287
InPort_694347
2 x OutPort_694361
InPort_694353
InPort_694415
2 x OutPort_694429
InPort_694421
InPort_694489
2 x OutPort_694503
InPort_694495
InPort_694564
2 x OutPort_694578
InPort_694570
InPort_694639
2 x OutPort_694653
InPort_694645
InPort_694707
2 x OutPort_694721
InPort_694713
InPort_694775
2 x OutPort_694793
InPort_694785
InPort_694856
2 x OutPort_694870
InPort_694862
InPort_694930
2 x OutPort_694944
InPort_694936
InPort_695005
2 x OutPort_695019
InPort_695011
InPort_695073
2 x OutPort_695087
InPort_695079

# IfcFlowFitting: Неспецифицируемый_серый (13)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Серый
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Серый; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_серый; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_серый
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый
Размеры - Длина короба: 1 mm; Радиус загиба: 5 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_серый:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
694227 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
694293 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
694361 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø | Идентификация - Вариант конструкции: Главная модель
694429 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
694503 | 15.675 | 25 | 12.5 | 0.00000702465 | 7.4928 | 25 ммøx25 ммø
694578 | 23.175 | 40 | 20 | 0.000025385 | 10.5994 | 40 ммøx40 ммø
694653 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
694721 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø | Идентификация - Вариант конструкции: Главная модель
694793 | 15.675 | 25 | 12.5 | 0.00000702465 | 7.4928 | 25 ммøx25 ммø
694870 | 19.175 | 32 | 16 | 0.0000137199 | 8.94255 | 32 ммøx32 ммø
694944 | 23.175 | 40 | 20 | 0.000025385 | 10.5994 | 40 ммøx40 ммø | Идентификация - Вариант конструкции: Главная модель
695019 | 28.175 | 50 | 25 | 0.0000473744 | 12.6705 | 50 ммøx50 ммø
695087 | 28.175 | 50 | 25 | 0.0000473744 | 12.6705 | 50 ммøx50 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая без протяжки 100м цвет серый (4)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая без протяжки 100м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая без протяжки 100м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая без протяжки 100м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая без протяжки 100м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16/20мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая без протяжки 100м цвет серый
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Материал: DKC_ПВХ_Серый; ADSK_Наименование: Труба ПВХ гибкая гофр. д.16-20мм, лёгкая без протяжки, 100м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.16-20мм, лёгкая с протяжкой, 100м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 90916
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая без протяжки 100м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16-20мм лёгкая без протяжки 100м цвет серый:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
694213 | 16 | 11.5 | 1994.37 | 16 ммø | 8 | -8 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
694219 | 16 | 11.5 | 614.371 | 16 ммø | 8 | -8
694281 | 20 | 14.9 | 1993.54 | 20 ммø | 10 | -10 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
694287 | 20 | 14.9 | 613.543 | 20 ммø | 10 | -10

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая без протяжки 25м цвет серый (8)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая без протяжки 25м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая без протяжки 25м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая без протяжки 25м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая без протяжки 25м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16/20/25/32мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая без протяжки 25м цвет серый
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Труба ПВХ гибкая гофр. д.16/20/25/32мм, лёгкая без протяжки, 25м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.16/20/25/32мм, лёгкая без протяжки, 25м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 9091625
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая без протяжки 25м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/32мм лёгкая без протяжки 25м цвет серый:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
694639 | 16 | 11.3 | 1994.37 | 16 ммø | 8 | -8 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
694645 | 16 | 11.3 | 614.371 | 16 ммø | 8 | -8 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
694707 | 20 | 14.7 | 1993.54 | 20 ммø | 10 | -10
694713 | 20 | 14.7 | 613.543 | 20 ммø | 10 | -10
694775 | 25 | 18.9 | 2115.69 | 25 ммø | 12.5 | -12.5
694785 | 25 | 18.9 | 612.507 | 25 ммø | 12.5 | -12.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
694856 | 32 | 24.6 | 1991.06 | 32 ммø | 16 | -16 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
694862 | 32 | 24.6 | 611.057 | 32 ммø | 16 | -16

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая без протяжки 50м цвет серый (8)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая без протяжки 50м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая без протяжки 50м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая без протяжки 50м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая без протяжки 50м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16/20/25/40мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая без протяжки 50м цвет серый
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Труба ПВХ гибкая гофр. д.16/20/25/40мм, лёгкая без протяжки, 50м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.16/20/25/40мм, лёгкая без протяжки, 50м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 9091650
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая без протяжки 50м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16/20/25/40мм лёгкая без протяжки 50м цвет серый:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm) | Вариант конструкции | sets with these values
694347 | 16 | 11.3 | 1994.37 | 16 ммø | 8 | -8
694353 | 16 | 11.3 | 614.371 | 16 ммø | 8 | -8 | Главная модель | 2
694415 | 20 | 14.7 | 1993.54 | 20 ммø | 10 | -10 | Главная модель | 2
694421 | 20 | 14.7 | 613.543 | 20 ммø | 10 | -10 | Главная модель | 2
694489 | 25 | 18.9 | 1992.51 | 25 ммø | 12.5 | -12.5
694495 | 25 | 18.9 | 612.507 | 25 ммø | 12.5 | -12.5 | Главная модель | 2
694564 | 40 | 31.5 | 1989.4 | 40 ммø | 20 | -20
694570 | 40 | 31.5 | 609.401 | 40 ммø | 20 | -20 | Главная модель | 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая без протяжки 20м цвет серый (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Идентификация - Вариант конструкции: Главная модель; sets with these values: 2; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая без протяжки 20м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая без протяжки 20м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая без протяжки 20м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая без протяжки 20м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая без протяжки 20м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 40 mm; Внутренний диаметр: 31.5 mm; Диаметр (Размер по каталогу): 40 mm; Размер: 40 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 20 mm; Нижняя отметка: -20 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.40мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая без протяжки 20м цвет серый
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Труба ПВХ гибкая гофр. д40мм, лёгкая без протяжки, 20м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.40мм, лёгкая без протяжки, 20м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 90940
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.40мм лёгкая без протяжки 20м цвет серый:...) | Длина (mm)
694930 | 1989.4
694936 | 609.401

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 15м цвет серый (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Идентификация - Вариант конструкции: Главная модель; sets with these values: 2; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 15м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 15м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 15м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 15м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 15м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 50 mm; Внутренний диаметр: 40.1 mm; Диаметр (Размер по каталогу): 50 mm; Размер: 50 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 25 mm; Нижняя отметка: -25 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.50мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 15м цвет серый
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Труба ПВХ гибкая гофр. д50мм, лёгкая без протяжки, 15м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.50мм, лёгкая без протяжки, 15м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 90950
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 15м цвет серый:...) | Длина (mm)
695005 | 1987.33
695011 | 607.33

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 30м цвет серый (2)
In: Этаж 01
Электросети - Стандартное: Стандартные типы коробов: ПВХ д.50мм; Верхняя отметка: 25 mm; Нижняя отметка: -25 mm; sets with these values: 2
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 30м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 30м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 30м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 30м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 50 mm; Внутренний диаметр: 40.1 mm; Диаметр (Размер по каталогу): 50 mm; Размер: 50 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 30м цвет серый
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Труба ПВХ гибкая гофр. д50мм, лёгкая без протяжки, 30м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.50мм, лёгкая без протяжки, 30м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Легкая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 9095030
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 30м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.50мм лёгкая без протяжки 30м цвет серый:...) | Длина (mm)
695073 | 1987.33
695079 | 607.33 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
