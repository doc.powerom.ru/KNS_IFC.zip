Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:04:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:04:23 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9E6A6ECE-23EF-4725-906A-CAB472A547AB}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:04:22 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:04:22 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:04:22 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes; Имя типа: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево; Текст: 225х175х145 мм
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial

# IfcFlowFitting: Смотровое устройство с крышкой, КНС_СмотровоеУстройствоСКрышкой_DKC_225x175x145:Смотровое устройство с крышкой:636798
In: Этаж 01
Type - Material: DKC_Пластик_Высокопрочный полипропилен
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025001; ADSK_Материал: DKC_Пластик_Высокопрочный полипропилен; ADSK_Наименование: Смотровой переходной колодец с крышкой для двустенных труб, 225х175х145мм; ADSK_Наименование краткое: Смотровой переходной колодец с крышкой для двустенных труб, 225х175х145мм; DKC_Степень защиты: IP 65; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025001/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Смотровое устройство с крышкой; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: устройство наружного освещения и сигнализации, подвод двустенных труб к мачтам освещения
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_СмотровоеУстройствоСКрышкой_DKC_225x175x145
Type - Размеры - ADSK_Размер_Высота: 145 mm; ADSK_Размер_Длина: 225 mm; ADSK_Размер_Ширина: 175 mm
Type - Текст - ADSK_Масса: 2.1
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Смотровое устройство с крышкой
Видимость - Видимость крышки: yes
Графика - Использовать масштаб аннотаций: no
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_СмотровоеУстройствоСКрышкой_DKC_225x175x145: Смотровое устройство с крышкой; Семейство: КНС_СмотровоеУстройствоСКрышкой_DKC_225x175x145: Смотровое устройство с крышкой; Семейство и типоразмер: КНС_СмотровоеУстройствоСКрышкой_DKC_225x175x145: Смотровое устройство с крышкой; Тип: КНС_СмотровоеУстройствоСКрышкой_DKC_225x175x145: Смотровое устройство с крышкой
Размеры - DN: 50 mm; DN2: 32 mm; Объем: 0.00211249 m3; Площадь: 0.222388 m2; Размер: 50 ммøx50 ммøx32 ммø
Стадии - Стадия возведения: Стадия 1
