Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:12:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:12:05 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{AA029E5A-C37B-4641-BC92-952C33754C66}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:12:04 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:12:04 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:12:04 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes; Имя типа: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300 (5)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.16мм 3x1,5мм² 25м
300 | Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с проводом ПуВ 3х1,5мм²/3х1,5мм² РЭК ГОСТ+, 25/50м
300 | д.16мм 3x1,5мм² 50м
300 | д.16мм 3x2,5мм² 50м
300 | д.16мм 3x2,5мм² 25м

# IfcDistributionPort (16)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_691714
2 x OutPort_691733
InPort_691720
InPort_691799
2 x OutPort_691815
InPort_691805
InPort_691835
2 x OutPort_691849
InPort_691841
InPort_691869
2 x OutPort_691883
InPort_691875

# IfcFlowFitting: Неспецифицируемый_серый (4)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Серый
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Серый; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_серый; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_серый
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый
Размеры - Длина короба: 1 mm; Метка радиуса загиба: 11.175 mm; Наружный диаметр фитинга: 16 mm; Наружный радиус фитинга: 8 mm; Номинальный диаметр: 16 mm; Номинальный радиус: 8 mm; Объем: 0.00000216672 m3; От центра до конца: 5.62884 mm; Радиус загиба: 5 mm; Размер: 16 ммøx16 ммø; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_серый:...) | Вариант конструкции
691733 | Главная модель
691815 | Главная модель
691849
691883 | Главная модель

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 25м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 25м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 25м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 25м; Тип: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 25м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 16 mm; Внутренний диаметр: 11.5 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 8 mm; Нижняя отметка: -8 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 25м
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Материал: DKC_ПВХ_Серый; ADSK_Наименование: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с проводом ПуВ 3х1,5мм² РЭК ГОСТ+, 25м; ADSK_Наименование краткое: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с проводом ПуВ 3х1,5мм² РЭК ГОСТ+, 25м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); DKC_Кол-во в бухте L_м: 25; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия); DKC_Разрывная прочность: не менее 100 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Тип кабеля: ПВ-1(ПуВ) 3х1,5; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; Тип трубопровода: 91627
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 25м; Комментарии к типоразмеру: Гофрированная электротруба из ПВХ
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 25м:...) | Длина (mm)
691714 | 1994.37
691720 | 614.371 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 16 mm; Внутренний диаметр: 11.5 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 8 mm; Нижняя отметка: -8 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с проводом ПуВ 3х1,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с проводом ПуВ 3х1,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия); DKC_Разрывная прочность: не менее 100 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Тип кабеля: ПВ-1(ПуВ) 3х1,5; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; Тип трубопровода: 91628
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПВХ
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х1,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
691799 | 1994.37
691805 | 614.371 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 25м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 25м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 25м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 25м; Тип: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 25м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 16 mm; Внутренний диаметр: 11.5 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 8 mm; Нижняя отметка: -8 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 25м
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с проводом ПуВ 3х2,5мм² РЭК ГОСТ+, 25м; ADSK_Наименование краткое: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с проводом ПуВ 3х2,5мм² РЭК ГОСТ+, 25м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); DKC_Кол-во в бухте L_м: 25; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия); DKC_Разрывная прочность: не менее 100 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Тип кабеля: ПВ-1(ПуВ) 3х2,5; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; Тип трубопровода: 91629
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 25м; Комментарии к типоразмеру: Гофрированная электротруба из ПВХ
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 25м:...) | Длина (mm)
691835 | 1994.37
691841 | 614.371 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 16 mm; Внутренний диаметр: 11.5 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 8 mm; Нижняя отметка: -8 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с проводом ПуВ 3х2,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с проводом ПуВ 3х2,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия); DKC_Разрывная прочность: не менее 100 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Тип кабеля: ПВ-1(ПуВ) 3х2,5; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; Тип трубопровода: 91630
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПВХ
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
691869 | 1994.37 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
691875 | 614.371
