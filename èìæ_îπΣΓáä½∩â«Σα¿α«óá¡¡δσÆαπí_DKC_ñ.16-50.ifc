Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:04:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:04:47 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{94396C31-E71C-41E9-B2F7-C28F220D1DD8}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:04:46 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:04:46 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:04:46 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (7)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.16мм | Главная модель
300 | д.20мм | Главная модель
300 | д.25мм | Главная модель
300 | д.32мм
300 | д.40мм | Главная модель
300 | д.50мм
300 | Муфта

# IfcFlowFitting: Муфта соединительная (6)
In: Этаж 01
Type - Material: DKC_Полиэтилен_Прозрачный
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Полиэтилен_Прозрачный; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Муфта соединительная; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: соединение гибких гофрированных труб; соединение гибких гофрированных труб с жесткими гладкими трубами
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Муфта соединительная
Графика - Использовать масштаб аннотаций: no
Данные - DKC_Степень защиты: IP40
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная; Семейство: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная; Семейство и типоразмер: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная; Тип: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Стадии - Стадия возведения: Стадия 1
Name (КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50:Муфта соединительная:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | D (mm) | DN (mm) | L (mm) | Объем (m3) | Размер | ADSK_Масса
646274 | 50816 | Муфта для труб гофрированных, IP40, д.16мм | 20 | 16 | 50 | 0.0000056546 | 16 ммøx16 ммø | 0.005
646286 | 50820 | Муфта для труб гофрированных, IP40, д.20мм | 24 | 20 | 55 | 0.00000760229 | 20 ммøx20 ммø | 0.006 | Идентификация - Вариант конструкции: Главная модель
646288 | 50825 | Муфта для труб гофрированных, IP40, д.25мм | 29 | 25 | 58 | 0.000009839 | 25 ммøx25 ммø | 0.009
646290 | 50832 | Муфта для труб гофрированных, IP40, д.32мм | 36 | 32 | 62 | 0.0000132443 | 32 ммøx32 ммø | 0.014 | Идентификация - Вариант конструкции: Главная модель
646292 | 50840 | Муфта для труб гофрированных, IP40, д.40мм | 45 | 40 | 81 | 0.000027036 | 40 ммøx40 ммø | 0.025
646294 | 50850 | Муфта для труб гофрированных, IP40, д.50мм | 55 | 50 | 92 | 0.0000379329 | 50 ммøx50 ммø | 0.034 | Идентификация - Вариант конструкции: Главная модель
