Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T17:07:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 17:07:19 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{CDEB46B0-15FD-4A1F-8D3C-FF92D31DB153}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 17:07:16 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 17:07:16 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 17:07:16 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (11)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.110мм SN6
300 | д.125мм SN6 | Главная модель
300 | д.160мм SN6 | Главная модель
300 | д.200мм SN6 | Главная модель
300 | Двустенная труба ПНД гибкая дренажная д.90-200мм, SN6/SN8, перфорация 360 град., в бухте 35-50м, цвет зеленый/черный | Главная модель
300 | д.90мм SN6
300 | д.110мм SN8 | Главная модель
300 | д.125мм SN8
300 | д.160мм SN8 | Главная модель
300 | д.200мм SN8
300 | д.90мм SN8

# IfcBuildingElementProxy: Текст модели:600 мм Arial
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 600 мм Arial
Графика - Горизонтальное выравнивание: Влево; Текст: ГИБКИЕ ДВУСТЕННЫЕ ДРЕНАЖНЫЕ ТРУБЫ
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Подкатегория: Обобщенные модели; Имя типа: 600 мм Arial
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 600 мм Arial; Семейство: Текст модели: 600 мм Arial; Семейство и типоразмер: Текст модели: 600 мм Arial; Тип: Текст модели: 600 мм Arial; Имя семейства: Текст модели
Размеры - Глубина:: 50 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 600 mm; Шрифт текста: Arial

# IfcDistributionPort (80)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_637303
2 x OutPort_686527
InPort_637304
2 x OutPort_686561
InPort_637305
2 x OutPort_686596
InPort_637306
2 x OutPort_686630
InPort_637340
2 x OutPort_686485
InPort_638456
2 x OutPort_686827
InPort_638457
2 x OutPort_686893
InPort_638458
2 x OutPort_686922
InPort_638459
2 x OutPort_686951
InPort_638466
2 x OutPort_686799
InPort_638654
2 x OutPort_686686
InPort_638655
2 x OutPort_686714
InPort_638656
2 x OutPort_686742
InPort_638657
2 x OutPort_686771
InPort_638664
2 x OutPort_686658
InPort_638671
2 x OutPort_687007
InPort_638672
2 x OutPort_687035
InPort_638673
2 x OutPort_687063
InPort_638674
2 x OutPort_687091
InPort_638681
2 x OutPort_686979
InPort_686474
InPort_686519
InPort_686547
InPort_686582
InPort_686616
InPort_686650
InPort_686678
InPort_686706
InPort_686734
InPort_686763
InPort_686791
InPort_686819
InPort_686885
InPort_686914
InPort_686943
InPort_686971
InPort_686999
InPort_687027
InPort_687055
InPort_687083

# IfcFlowFitting: Неспецифицируемый_зеленый (10)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Зеленый
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Зеленый; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_зеленый; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_зеленый
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_зеленый; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_зеленый; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_зеленый; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_зеленый
Размеры - Длина короба: 1 mm; Радиус загиба: 10 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_зеленый:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер | Вариант конструкции
686485 | 48.175 | 90 | 45 | 0.000253418 | 20.9547 | 90 ммøx90 ммø
686527 | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø | Главная модель
686561 | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø | Главная модель
686596 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø | Главная модель
686630 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø | Главная модель
686799 | 48.175 | 90 | 45 | 0.000253418 | 20.9547 | 90 ммøx90 ммø | Главная модель
686827 | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø
686893 | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø
686922 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø | Главная модель
686951 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø | Главная модель

# IfcFlowFitting: Неспецифицируемый_черный (10)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Черный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Черный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_черный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_черный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Размеры - Угол: 45 deg; Длина короба: 1 mm; Радиус загиба: 10 mm
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_черный:...) | Вариант конструкции | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
686658 | Главная модель | 48.175 | 90 | 45 | 0.000253418 | 20.9547 | 90 ммøx90 ммø
686686 |  | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø
686714 | Главная модель | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø
686742 | Главная модель | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø
686771 | Главная модель | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø
686979 |  | 48.175 | 90 | 45 | 0.000253418 | 20.9547 | 90 ммøx90 ммø
687007 | Главная модель | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø
687035 | Главная модель | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø
687063 |  | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø
687091 |  | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN6 перфорация 360 град. в бухте 35-50м цвет зеленый (10)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN6 перфорация 360 град. в бухте 35-50м цвет зеленый; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN6 перфорация 360 град. в бухте 35-50м цвет зеленый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN6 перфорация 360 град. в бухте 35-50м цвет зеленый; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN6 перфорация 360 град. в бухте 35-50м цвет зеленый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая дренажная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN6 перфорация 360 град. в бухте 35-50м цвет зеленый
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-015-47022248-2006; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Зеленый; ADSK_Наименование: Двустенная труба ПНД гибкая дренажная д.90-200мм, SN6, перфорация 360 град., в бухте 35-50м, цвет зеленый; ADSK_Наименование краткое: Двустенная труба ПНД гибкая дренажная д.90-200мм, SN6, перфорация 360 град., в бухте 35-50м, цвет зеленый; DKC_Класс жесткости трубы: SN6; DKC_Кол-во в бухте L_м: д.90 SN6=50 / д.110 SN6=50 / д.125 SN6=40 / д.160 SN6=50 / д.200 SN6=35; DKC_Минимальный радиус изгиба (количество диаметров): 8; DKC_Температура эксплуатации: от –40 до + 90 °С; Тип трубопровода: 140990
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/88/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN6 перфорация 360 град. в бухте 35-50м цвет зеленый; Комментарии к типоразмеру: Двустенные гибкие дренажные трубы
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_зеленый; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN6 перфорация 360 град. в бухте 35-50м цвет зеленый:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
637303 | 110 | 94 | 1949.81 | 110 ммø | 55 | -55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
637304 | 125 | 107 | 1943.59 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
637305 | 160 | 137 | 1929.1 | 160 ммø | 80 | -80
637306 | 200 | 172 | 1912.53 | 200 ммø | 100 | -100
637340 | 90 | 77 | 1953.95 | 90 ммø | 45 | -45
686474 | 90 | 77 | 679.045 | 90 ммø | 45 | -45 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686519 | 110 | 94 | 574.903 | 110 ммø | 55 | -55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686547 | 125 | 107 | 571.797 | 125 ммø | 62.5 | -62.5
686582 | 160 | 137 | 564.548 | 160 ммø | 80 | -80
686616 | 200 | 172 | 656.264 | 200 ммø | 100 | -100 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN8 перфорация 360 град. в бухте 35-50м цвет зеленый (10)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN8 перфорация 360 град. в бухте 35-50м цвет зеленый; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN8 перфорация 360 град. в бухте 35-50м цвет зеленый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN8 перфорация 360 град. в бухте 35-50м цвет зеленый; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN8 перфорация 360 град. в бухте 35-50м цвет зеленый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая дренажная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN8 перфорация 360 град. в бухте 35-50м цвет зеленый
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Зеленый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-015-47022248-2006; ADSK_Наименование: Двустенная труба ПНД гибкая дренажная д.90-200мм, SN8, перфорация 360 град., в бухте 35-50м, цвет зеленый; ADSK_Наименование краткое: Двустенная труба ПНД гибкая дренажная д.90-200мм, SN8, перфорация 360 град., в бухте 35-50м, цвет зеленый; DKC_Класс жесткости трубы: SN8; DKC_Кол-во в бухте L_м: д.90 SN8=50 / д.110 SN8=50 / д.125 SN8=40 / д.160 SN8=50 / д.200 SN8=35; DKC_Минимальный радиус изгиба (количество диаметров): 8; DKC_Температура эксплуатации: от –40 до + 90 °С; Тип трубопровода: 140991
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/88/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN8 перфорация 360 град. в бухте 35-50м цвет зеленый; Комментарии к типоразмеру: Двустенные гибкие дренажные трубы
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_зеленый; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм SN8 перфорация 360 град. в бухте 35-50м цвет зеленый:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
638456 | 110 | 94 | 1949.81 | 110 ммø | 55 | -55
638457 | 125 | 107 | 1943.59 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638458 | 160 | 137 | 1929.1 | 160 ммø | 80 | -80
638459 | 200 | 172 | 1912.53 | 200 ммø | 100 | -100 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638466 | 90 | 77 | 1953.95 | 90 ммø | 45 | -45
686791 | 90 | 77 | 579.045 | 90 ммø | 45 | -45 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686819 | 110 | 94 | 574.903 | 110 ммø | 55 | -55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686885 | 125 | 107 | 571.797 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686914 | 160 | 137 | 564.548 | 160 ммø | 80 | -80
686943 | 200 | 172 | 556.264 | 200 ммø | 100 | -100

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN6 перфорация 360 град. в бухте 35-50м цвет черный (10)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN6 перфорация 360 град. в бухте 35-50м цвет черный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN6 перфорация 360 град. в бухте 35-50м цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN6 перфорация 360 град. в бухте 35-50м цвет черный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN6 перфорация 360 град. в бухте 35-50м цвет черный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая дренажная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN6 перфорация 360 град. в бухте 35-50м цвет черный
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-015-47022248-2006; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Наименование: Двустенная труба ПНД гибкая дренажная д.90-200мм с геофильтром, SN6, перфорация 360 град., в бухте 35-50м, цвет черный; ADSK_Наименование краткое: Двустенная труба ПНД гибкая дренажная д.90-200мм с геофильтром, SN6, перфорация 360 град., в бухте 35-50м, цвет черный; DKC_Геотекстиль: TYPAR, SF-27; DKC_Класс жесткости трубы: SN6; DKC_Кол-во в бухте L_м: д.90 SN6=50 / д.110 SN6=50 / д.125 SN6=40 / д.160 SN6=50 / д.200 SN6=35; DKC_Минимальный радиус изгиба (количество диаметров): 8; DKC_Температура эксплуатации: от –40 до + 90 °С; Тип трубопровода: 140992
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/88/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN6 перфорация 360 град. в бухте 35-50м цвет черный; Комментарии к типоразмеру: Двустенные гибкие дренажные трубы
Соединительные детали - Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN6 перфорация 360 град. в бухте 35-50м цвет черный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
638654 | 110 | 94 | 1949.81 | 110 ммø | 55 | -55
638655 | 125 | 107 | 1943.59 | 125 ммø | 62.5 | -62.5
638656 | 160 | 137 | 1929.1 | 160 ммø | 80 | -80
638657 | 200 | 172 | 1912.53 | 200 ммø | 100 | -100 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638664 | 90 | 77 | 1953.95 | 90 ммø | 45 | -45
686650 | 90 | 77 | 579.045 | 90 ммø | 45 | -45
686678 | 110 | 94 | 574.903 | 110 ммø | 55 | -55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686706 | 125 | 107 | 571.797 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686734 | 160 | 137 | 564.548 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686763 | 200 | 172 | 556.264 | 200 ммø | 100 | -100 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN8 перфорация 360 град. в бухте 35-50м цвет черный (10)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN8 перфорация 360 град. в бухте 35-50м цвет черный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN8 перфорация 360 град. в бухте 35-50м цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN8 перфорация 360 град. в бухте 35-50м цвет черный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN8 перфорация 360 град. в бухте 35-50м цвет черный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая дренажная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN8 перфорация 360 град. в бухте 35-50м цвет черный
Соединительные детали - Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/88/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN8 перфорация 360 град. в бухте 35-50м цвет черный; Комментарии к типоразмеру: Двустенные гибкие дренажные трубы
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-015-47022248-2006; ADSK_Наименование: Двустенная труба ПНД гибкая дренажная д.90-200мм с геофильтром, SN8, перфорация 360 град., в бухте 35-50м, цвет черный; ADSK_Наименование краткое: Двустенная труба ПНД гибкая дренажная д.90-200мм с геофильтром, SN8, перфорация 360 град., в бухте 35-50м, цвет черный; DKC_Геотекстиль: TYPAR, SF-27; DKC_Класс жесткости трубы: SN8; DKC_Кол-во в бухте L_м: д.90 SN8=50 / д.110 SN8=50 / д.125 SN8=40 / д.160 SN8=50 / д.200 SN8=35; DKC_Минимальный радиус изгиба (количество диаметров): 8; DKC_Температура эксплуатации: от –40 до + 90 °С; Тип трубопровода: 140993
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая дренажная_DKC_д.90-200мм с геофильтром SN8 перфорация 360 град. в бухте 35-50м цвет черный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
638671 | 110 | 94 | 1949.81 | 110 ммø | 55 | -55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638672 | 125 | 107 | 1943.59 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638673 | 160 | 137 | 1929.1 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638674 | 200 | 172 | 1912.53 | 200 ммø | 100 | -100
638681 | 90 | 77 | 1953.95 | 90 ммø | 45 | -45 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686971 | 90 | 77 | 579.045 | 90 ммø | 45 | -45 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686999 | 110 | 94 | 574.903 | 110 ммø | 55 | -55
687027 | 125 | 107 | 571.797 | 125 ммø | 62.5 | -62.5
687055 | 160 | 137 | 564.548 | 160 ммø | 80 | -80
687083 | 200 | 172 | 556.264 | 200 ммø | 100 | -100
