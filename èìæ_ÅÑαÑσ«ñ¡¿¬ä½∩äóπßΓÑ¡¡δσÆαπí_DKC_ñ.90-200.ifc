Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:01:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:01:59 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{AFD17914-8D2A-40C0-9392-458414397CAF}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:01:58 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:01:58 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:01:58 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (5)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.125-140мм
300 | д.140-160мм | Главная модель
300 | д.160-200мм
300 | д.110-125мм | Главная модель
300 | д.90-110мм | Главная модель

# IfcFlowFitting: Кольцо резиновое уплотнительное (10)
In: Этаж 01
Type - Material: DKC_Резина
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Резина; DKC_Степень защиты: IP 55 с аксессуарами; DKC_Температура эксплуатации: от –25 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Кольцо резиновое уплотнительное; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: герметизация мест соединения гибких, жестких, дренажных гофрированных двустенных труб с соединительными муфтами, заглушками, разветвителями, переходниками
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Кольцо резиновое уплотнительное
Зависимости - Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no
Прочее - Код типа: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Семейство: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Семейство и типоразмер: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Тип: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное
Стадии - Стадия возведения: Стадия 1
Name (КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200:Кольцо резиновое уплотнительное:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | Смещение (mm) | A (mm) | DN (mm) | Dвнеш (mm) | Dвнут (mm) | Объем (m3) | ADSK_Масса
566641 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 0 | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
566643 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | -3 | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009
568734 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 4.5 | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016 | Идентификация - Вариант конструкции: Главная модель
568736 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 0 | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
569011 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 0 | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019
569013 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | -4.5 | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016
569115 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 0 | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Идентификация - Вариант конструкции: Главная модель
569117 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | -6.5 | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019 | Идентификация - Вариант конструкции: Главная модель
569264 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 0 | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06 | Идентификация - Вариант конструкции: Главная модель
569266 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | -15.5 | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Идентификация - Вариант конструкции: Главная модель

# IfcFlowFitting: Переходник (5)
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Оранжевый
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Пластик_Полипропилен_Оранжевый; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Переходник; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: соединение гибких, жестких, дренажных гофрированных двустенных труб разных диаметров с обеспечением плавного перехода
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник
Видимость - DKC_Уплотнительные резиновые кольца: yes
Графика - Использовать масштаб аннотаций: no
Данные - DKC_Степень защиты: IP 55
Зависимости - Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Семейство: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Семейство и типоразмер: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Тип: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник
Стадии - Стадия возведения: Стадия 1
Name (КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200:Переходник:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | Смещение (mm) | D1 (mm) | D2 (mm) | D3 (mm) | D4 (mm) | D5 (mm) | D6 (mm) | DN (mm) | DN2 (mm) | L1 (mm) | L2 (mm) | Объем (m3) | Размер | ADSK_Масса
566635 | 024110 | Переходник для двустенных труб полипропилен д.90-110мм | 0 | 104 | 114 | 92 | 108 | 88 | 120 | 110 | 90 | 109 | 70 | 0.000271474 | 110 ммøx90 ммø | 0.11
568732 | 024125 | Переходник для двустенных труб полипропилен д.110-125мм | 4.5 | 117 | 129 | 111 | 120 | 102 | 135 | 125 | 110 | 130 | 68 | 0.000290745 | 125 ммøx110 ммø | 0.252
569009 | 024140 | Переходник для двустенных труб полипропилен д.125-140мм | 0 | 134 | 144 | 126 | 135 | 122 | 150 | 140 | 125 | 140 | 75 | 0.000326729 | 140 ммøx125 ммø | 0.3
569113 | 024160 | Переходник для двустенных труб полипропилен д.140-160мм | 0 | 153 | 164 | 141 | 151 | 132 | 170 | 160 | 140 | 144 | 81 | 0.000418155 | 160 ммøx140 ммø | 0.382
569262 | 024200 | Переходник для двустенных труб полипропилен д.160-200мм | 0 | 190 | 202 | 161 | 171 | 149 | 208 | 200 | 160 | 240 | 140 | 0.000825316 | 200 ммøx160 ммø | 0.782
