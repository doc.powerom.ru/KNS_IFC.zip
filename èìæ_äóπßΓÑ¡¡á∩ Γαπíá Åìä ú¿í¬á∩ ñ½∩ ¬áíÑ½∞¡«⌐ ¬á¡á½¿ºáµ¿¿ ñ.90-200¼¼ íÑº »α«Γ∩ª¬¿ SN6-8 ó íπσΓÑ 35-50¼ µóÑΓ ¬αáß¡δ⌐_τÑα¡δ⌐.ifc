Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T17:31:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 17:31:27 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{EF2ED177-A810-4ADB-8A44-AA1E0C4A10B1}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 17:31:26 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 17:31:26 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 17:31:26 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (6)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.90мм
300 | д.110мм | Главная модель
300 | д.125мм | Главная модель
300 | д.160мм | Главная модель
300 | д.200мм
300 | Двустенная труба ПНД гибкая для кабельной канализации, д.63-200мм с протяжкой, SN6-13, в бухте 35-50м, цвет красный/черный | Главная модель

# IfcDistributionPort (40)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_644074
2 x OutPort_644076
InPort_644075
InPort_644078
2 x OutPort_644080
InPort_644079
InPort_644082
2 x OutPort_644084
InPort_644083
InPort_644090
2 x OutPort_644092
InPort_644091
InPort_644094
2 x OutPort_644096
InPort_644095
InPort_644473
2 x OutPort_644475
InPort_644474
InPort_644477
2 x OutPort_644479
InPort_644478
InPort_644481
2 x OutPort_644483
InPort_644482
InPort_644485
2 x OutPort_644487
InPort_644486
InPort_644489
2 x OutPort_644491
InPort_644490

# IfcFlowFitting: Неспецифицируемый_красный (5)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Красный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Красный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_красный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_красный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный
Размеры - Длина короба: 1 mm; Радиус загиба: 10 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_красный:...) | Вариант конструкции | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
644076 | Главная модель | 48.175 | 90 | 45 | 0.000253418 | 20.9547 | 90 ммøx90 ммø
644080 | Главная модель | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø
644084 | Главная модель | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø
644092 |  | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø
644096 | Главная модель | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø

# IfcFlowFitting: Неспецифицируемый_черный (5)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Черный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Черный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_черный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_черный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Размеры - Угол: 45 deg; Длина короба: 1 mm; Радиус загиба: 10 mm
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_черный:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
644475 | 48.175 | 90 | 45 | 0.000253418 | 20.9547 | 90 ммøx90 ммø
644479 | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø | Идентификация - Вариант конструкции: Главная модель
644483 | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø
644487 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø | Идентификация - Вариант конструкции: Главная модель
644491 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет красный (10)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет красный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет красный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет красный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет красный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая ливневая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет красный
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-015-47022248-2006; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Красный; ADSK_Наименование: Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки, SN6-8, в бухте 35-50м, цвет красный; ADSK_Наименование краткое: Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки, SN6-8, в бухте 35-50м, цвет красный; DKC_Кол-во в бухте L_м: д.90 SN8=50 / д.110 SN8=50 / д.125 SN8=40 / д.160 SN6=50 / д.200 SN6=35; DKC_Кольцевая жесткость_кПа: д.90 SN8=8 / д.110 SN8=8 / д.125 SN8=8 / д.160 SN6=6 / д.200 SN6=6; DKC_Температура монтажа: от –25 до + 90 °С; DKC_Температура транспортируемой жидкости: до +60 ºС; DKC_Температура эксплуатации: от –55 до + 90 °С; Тип трубопровода: 120990
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/89/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет красный; Комментарии к типоразмеру: Ливневая канализация (красные/черные (А))
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет красный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
644074 | 90 | 77 | 1979.05 | 90 ммø | 45 | -45
644075 | 90 | 77 | 979.045 | 90 ммø | 45 | -45 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
644078 | 110 | 94 | 1974.9 | 110 ммø | 55 | -55
644079 | 110 | 94 | 974.903 | 110 ммø | 55 | -55
644082 | 125 | 107 | 1971.8 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
644083 | 125 | 107 | 971.797 | 125 ммø | 62.5 | -62.5
644090 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
644091 | 160 | 137 | 964.548 | 160 ммø | 80 | -80
644094 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
644095 | 200 | 172 | 956.264 | 200 ммø | 100 | -100 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет черный (10)
In: Этаж 01
Электросети - Стандартное: Стандартные типы коробов: ПНД гибкая ливневая; sets with these values: 2
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет черный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет черный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет черный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет черный
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/89/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет черный; Комментарии к типоразмеру: Ливневая канализация (красные/черные (А))
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-015-47022248-2006; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Наименование: Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки, SN6-8, в бухте 35-50м, цвет черный; ADSK_Наименование краткое: Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки, SN6-8, в бухте 35-50м, цвет черный; DKC_Кол-во в бухте L_м: д.90 SN8=50 / д.110 SN8=50 / д.125 SN8=40 / д.160 SN6=50 / д.200 SN6=35; DKC_Кольцевая жесткость_кПа: д.90 SN8=8 / д.110 SN8=8 / д.125 SN8=8 / д.160 SN6=6 / д.200 SN6=6; DKC_Температура монтажа: от –25 до + 90 °С; DKC_Температура транспортируемой жидкости: до +60 ºС; DKC_Температура эксплуатации: от –55 до + 90 °С; Тип трубопровода: 120991
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.90-200мм без протяжки SN6-8 в бухте 35-50м цвет черный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
644473 | 90 | 77 | 1979.05 | 90 ммø | 45 | -45
644474 | 90 | 77 | 979.045 | 90 ммø | 45 | -45
644477 | 110 | 94 | 1974.9 | 110 ммø | 55 | -55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
644478 | 110 | 94 | 974.903 | 110 ммø | 55 | -55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
644481 | 125 | 107 | 1971.8 | 125 ммø | 62.5 | -62.5
644482 | 125 | 107 | 971.797 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
644485 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80
644486 | 160 | 137 | 964.548 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
644489 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
644490 | 200 | 172 | 956.264 | 200 ммø | 100 | -100
