Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:02:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:02:51 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{967E2BAB-9F16-4B28-BF99-7B764590AF8D}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:02:49 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:02:49 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:02:49 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (15)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.63мм | Главная модель
300 | д.90мм
300 | д.110мм | Главная модель
2 x 300 | д.125мм
2 x 300 | д.140мм | Главная модель
2 x 300 | д.160мм | Главная модель
300 | д.200мм | Главная модель
300 | д.63мм
300 | д.110мм
300 | д.200мм
300 | Крестовина 90° | Главная модель
300 | Крестовина 45°

# IfcFlowFitting: Кольцо резиновое уплотнительное (52)
In: Этаж 01
Type - Material: DKC_Резина
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Резина; DKC_Степень защиты: IP 55 с аксессуарами; DKC_Температура эксплуатации: от –25 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Кольцо резиновое уплотнительное; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: герметизация мест соединения гибких, жестких, дренажных гофрированных двустенных труб с соединительными муфтами, заглушками, разветвителями, переходниками
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Кольцо резиновое уплотнительное
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no
Прочее - Код типа: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Семейство: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Семейство и типоразмер: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Тип: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное
Стадии - Стадия возведения: Стадия 1
Name (КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200:Кольцо резиновое уплотнительное:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | A (mm) | DN (mm) | Dвнеш (mm) | Dвнут (mm) | Объем (m3) | ADSK_Масса
618280 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004 | Идентификация - Вариант конструкции: Главная модель
618282 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004
618284 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004
618292 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009
618294 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009 | Идентификация - Вариант конструкции: Главная модель
618296 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009
618298 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
618300 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
618302 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
618304 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016 | Идентификация - Вариант конструкции: Главная модель
618306 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016 | Идентификация - Вариант конструкции: Главная модель
618308 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016
618310 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019 | Идентификация - Вариант конструкции: Главная модель
618312 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019 | Идентификация - Вариант конструкции: Главная модель
618314 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019 | Идентификация - Вариант конструкции: Главная модель
618316 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Идентификация - Вариант конструкции: Главная модель
618318 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Идентификация - Вариант конструкции: Главная модель
618320 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031
618322 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06
618324 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06 | Идентификация - Вариант конструкции: Главная модель
618326 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06 | Идентификация - Вариант конструкции: Главная модель
618402 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004
618406 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009
618408 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015 | Идентификация - Вариант конструкции: Главная модель
618410 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016 | Идентификация - Вариант конструкции: Главная модель
618412 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019
618414 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Идентификация - Вариант конструкции: Главная модель
618416 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06
618648 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004
618650 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004
618652 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004 | Идентификация - Вариант конструкции: Главная модель
618660 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
618662 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
618664 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
618666 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016
618668 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016
618670 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016
618672 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019 | Идентификация - Вариант конструкции: Главная модель
618674 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019
618676 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019 | Идентификация - Вариант конструкции: Главная модель
618678 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Идентификация - Вариант конструкции: Главная модель
618680 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Идентификация - Вариант конструкции: Главная модель
618682 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031
618684 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06
618686 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06 | Идентификация - Вариант конструкции: Главная модель
618688 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06 | Идентификация - Вариант конструкции: Главная модель
618690 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004 | Идентификация - Вариант конструкции: Главная модель
618694 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
618696 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016
618698 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019 | Идентификация - Вариант конструкции: Главная модель
618700 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031
618702 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06

# IfcFlowFitting: Крестовина (13)
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Оранжевый
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Пластик_Полипропилен_Оранжевый; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: Крестовина; Описание: Назначение: механическое неразъемное соединение гибких, жестких, дренажных гофрированных двустенных труб одного диаметра
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Крестовина
Видимость - DKC_Уплотнительные резиновые кольца: yes
Графика - Использовать масштаб аннотаций: no
Данные - DKC_Степень защиты: IP 55
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Семейство: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Семейство и типоразмер: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Тип: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина
Стадии - Стадия возведения: Стадия 1
Name (КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200:Крестовина:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | D1 (mm) | D2 (mm) | D2половина (mm) | D3 (mm) | D4 (mm) | D4половина (mm) | D4половина-L (mm) | DN (mm) | L (mm) | L1 (mm) | L2 (mm) | L-D4половина (mm) | Объем (m3) | Размер | Угол (deg) = Угол1 (deg) | ADSK_Масса
618263 | 022063 | Крестообразное соед. для двустенных труб, 90 град., полипропилен, д.63мм | 55 | 59 | 29.5 | 64 | 69 | 34.5 | -62 | 63 | 96.5 | 193 | 193 | 62 | 0.0010224 | 63 ммøx63 ммøx63 ммøx63 ммø | 90 | 0.34 | Идентификация - Вариант конструкции: Главная модель
618268 | 022090 | Крестообразное соед. для двустенных труб, 90 град., полипропилен, д.90мм | 86 | 86 | 43 | 91 | 94 | 47 | -82 | 90 | 129 | 232 | 258 | 82 | 0.00258164 | 90 ммøx90 ммøx90 ммøx90 ммø | 90 | 0.363 | Идентификация - Вариант конструкции: Главная модель
618270 | 022110 | Крестообразное соед. для двустенных труб, 90 град., полипропилен, д.110мм | 104 | 106 | 53 | 111 | 116 | 58 | -71 | 110 | 129 | 242 | 258 | 71 | 0.00392157 | 110 ммøx110 ммøx110 ммøx110 ммø | 90 | 0.53
618272 | 022125 | Крестообразное соед. для двустенных труб, 90 град., полипропилен, д.125мм | 118 | 121 | 60.5 | 126 | 130 | 65 | -75 | 125 | 140 | 274 | 280 | 75 | 0.00553514 | 125 ммøx125 ммøx125 ммøx125 ммø | 90 | 0.685
618274 | 022140 | Крестообразное соед. для двустенных труб, 90 град., полипропилен, д.140мм | 132 | 136 | 68 | 141 | 145 | 72.5 | -82.5 | 140 | 155 | 278 | 310 | 82.5 | 0.00729644 | 140 ммøx140 ммøx140 ммøx140 ммø | 90 | 0.84 | Идентификация - Вариант конструкции: Главная модель
618276 | 022160 | Крестообразное соед. для двустенных труб, 90 град., полипропилен, д.160мм | 155 | 156 | 78 | 161 | 165 | 82.5 | -91.5 | 160 | 174 | 338 | 348 | 91.5 | 0.011142 | 160 ммøx160 ммøx160 ммøx160 ммø | 90 | 1.05
618278 | 022200 | Крестообразное соед. для двустенных труб, 90 град., полипропилен, д.200мм | 193 | 196 | 98 | 201 | 207 | 103.5 | -103.5 | 200 | 207 | 406 | 414 | 103.5 | 0.0208014 | 200 ммøx200 ммøx200 ммøx200 ммø | 90 | 1.85 | Идентификация - Вариант конструкции: Главная модель
618634 | 021063 | Соединение для четырех двустенных труб, 45 град., полипропилен, д.63мм | 55 | 59 | 29.5 | 64 | 68 | 34 | -82.0833 | 63 | 116.083 | 198 | 208 | 82.0833 | 0.00107395 | 63 ммøx63 ммøx63 ммøx63 ммø | 45 | 0.42
618638 | 021110 | Соединение для четырех двустенных труб, 45 град., полипропилен, д.110мм | 103 | 106 | 53 | 111 | 116 | 58 | -140.024 | 110 | 198.024 | 283 | 355 | 140.024 | 0.00517275 | 110 ммøx110 ммøx110 ммøx110 ммø | 45 | 1.28 | Идентификация - Вариант конструкции: Главная модель
618640 | 021125 | Соединение для четырех двустенных труб, 45 град., полипропилен, д.125мм | 116 | 121 | 60.5 | 126 | 129 | 64.5 | -155.717 | 125 | 220.217 | 332 | 378 | 155.717 | 0.00751571 | 125 ммøx125 ммøx125 ммøx125 ммø | 45 | 0.956 | Идентификация - Вариант конструкции: Главная модель
618642 | 021140 | Соединение для четырех двустенных труб, 45 град., полипропилен, д.140мм | 132 | 136 | 68 | 141 | 145 | 72.5 | -175.03 | 140 | 247.53 | 370 | 404 | 175.03 | 0.0106267 | 140 ммøx140 ммøx140 ммøx140 ммø | 45 | 1.378
618644 | 021160 | Соединение для четырех двустенных труб, 45 град., полипропилен, д.160мм | 155 | 156 | 78 | 162 | 166 | 83 | -200.38 | 160 | 283.38 | 395 | 480 | 200.38 | 0.0154331 | 160 ммøx160 ммøx160 ммøx160 ммø | 45 | 1.58
618646 | 021200 | Соединение для четырех двустенных труб, 45 град., полипропилен, д.200мм | 193 | 196 | 98 | 202 | 207 | 103.5 | -249.871 | 200 | 353.371 | 568 | 671 | 249.871 | 0.0324425 | 200 ммøx200 ммøx200 ммøx200 ммø | 45 | 3.1
