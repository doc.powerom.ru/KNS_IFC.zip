Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:08:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:08:45 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{A107D935-5525-4922-9A8F-13223DFC69F2}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:08:44 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:08:45 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:08:45 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (5)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.16мм
300 | Втулка концевая для заливки в бетон
300 | д.20мм | Идентификация - Вариант конструкции: Главная модель
300 | д.25мм
300 | д.32мм

# IfcFlowFitting: Втулка концевая (4)
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Красный
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Пластик_Полипропилен_Красный
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Втулка концевая; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: увеличение глубины установочных коробок и коробок потолочных для заливки в бетон
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ВтулкаКонцеваяДляЗаливкиВБетон_DKC
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Втулка концевая
Графика - Использовать масштаб аннотаций: no
Данные - ADSK_Код изделия: 59389
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_ВтулкаКонцеваяДляЗаливкиВБетон_DKC: Втулка концевая; Семейство: КНС_ВтулкаКонцеваяДляЗаливкиВБетон_DKC: Втулка концевая; Семейство и типоразмер: КНС_ВтулкаКонцеваяДляЗаливкиВБетон_DKC: Втулка концевая; Тип: КНС_ВтулкаКонцеваяДляЗаливкиВБетон_DKC: Втулка концевая
Стадии - Стадия возведения: Стадия 1
Name (КНС_ВтулкаКонцеваяДляЗаливкиВБетон_DKC:Втулка концевая:...) | ADSK_Наименование = ADSK_Наименование краткое | Вариант конструкции | A (mm) | B (mm) | C (mm) | DN (mm) | E (mm) | F (mm) | Объем (m3) | Площадь (m2) | Размер | ADSK_Масса
761729 | Втулка концевая для заливки в бетон, д.16 и 25 мм | Главная модель | 53 | 33 | 28 | 16 | 8 | 6 | 0.00000671109 | 0.00359639 | 16 ммø | 0.006
763031 | Втулка концевая для заливки в бетон, д.20 и 32 мм | Главная модель | 65 | 40 | 33 | 20 | 9 | 7 | 0.00000901947 | 0.00480771 | 20 ммø | 0.011
763040 | Втулка концевая для заливки в бетон, д.16 и 25 мм | Главная модель | 53 | 33 | 28 | 25 | 8 | 6 | 0.00000671109 | 0.00359639 | 25 ммø | 0.006
763049 | Втулка концевая для заливки в бетон, д.20 и 32 мм |  | 65 | 40 | 33 | 32 | 9 | 7 | 0.00000901947 | 0.00480771 | 32 ммø | 0.011
