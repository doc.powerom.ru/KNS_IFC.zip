Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T19:58:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 19:58:01 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{AC4BEEDC-149F-4D0F-B1CA-FF0007ABF782}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 19:58:00 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 19:58:01 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 19:58:01 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (10)
In: Этаж 01
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Прочее - Категория: Обобщенные модели; Имя семейства: Текст модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300
Идентификация - Имя типа: 300; Подкатегория: Обобщенные модели
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Name (Текст модели:...) | Текст
300 | д.50мм | Идентификация - Вариант конструкции: Главная модель
300 | д.63мм | Идентификация - Вариант конструкции: Главная модель
300 | д.75мм
300 | д.90мм
300 | д.110мм | Идентификация - Вариант конструкции: Главная модель
300 | д.125мм
300 | д.140мм | Идентификация - Вариант конструкции: Главная модель
300 | д.160мм
300 | д.200мм
300 | Муфта | Идентификация - Вариант конструкции: Главная модель

# IfcFlowFitting: Кольцо резиновое уплотнительное (18)
In: Этаж 01
Type - Material: DKC_Резина
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Резина; DKC_Степень защиты: IP 55 с аксессуарами; DKC_Температура эксплуатации: от –25 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Кольцо резиновое уплотнительное; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: герметизация мест соединения гибких, жестких, дренажных гофрированных двустенных труб с соединительными муфтами, заглушками, разветвителями, переходниками
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Кольцо резиновое уплотнительное
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no
Прочее - Код типа: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Семейство: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Семейство и типоразмер: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Тип: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное
Стадии - Стадия возведения: Стадия 1
Name (КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200:Кольцо резиновое уплотнительное:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | A (mm) | DN (mm) | Dвнеш (mm) | Dвнут (mm) | Объем (m3) | ADSK_Масса
547751 | 016050 | Кольцо резиновое уплотнительное для двустенной трубы 50мм | 2 | 50 | 49.5 | 39 | 0.00000145959 | 0.002
547753 | 016050 | Кольцо резиновое уплотнительное для двустенной трубы 50мм | 2 | 50 | 49.5 | 39 | 0.00000145959 | 0.002 | Идентификация - Вариант конструкции: Главная модель
547757 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004 | Идентификация - Вариант конструкции: Главная модель
547759 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004 | Идентификация - Вариант конструкции: Главная модель
547764 | 016075 | Кольцо резиновое уплотнительное для двустенной трубы 75мм | 2 | 75 | 74.6 | 60.4 | 0.00000301107 | 0.007 | Идентификация - Вариант конструкции: Главная модель
547766 | 016075 | Кольцо резиновое уплотнительное для двустенной трубы 75мм | 2 | 75 | 74.6 | 60.4 | 0.00000301107 | 0.007
547771 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009 | Идентификация - Вариант конструкции: Главная модель
547773 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009
547778 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
547780 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015 | Идентификация - Вариант конструкции: Главная модель
547785 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016
547787 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016
547792 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019
547794 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019
547799 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Идентификация - Вариант конструкции: Главная модель
547801 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031 | Идентификация - Вариант конструкции: Главная модель
547806 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06
547808 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06 | Идентификация - Вариант конструкции: Главная модель

# IfcFlowFitting: Муфта соединительная (9)
In: Этаж 01
Type - Material: DKC_Пластик_Полиэтилен
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Пластик_Полиэтилен; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Муфта соединительная; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: механическое неразъемное соединение гибких, жестких, дренажных гофрированных двустенных труб одного диаметра
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Муфта соединительная
Видимость - DKC_Уплотнительные резиновые кольца: yes
Графика - Использовать масштаб аннотаций: no
Данные - DKC_Степень защиты: IP 55
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Семейство: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Семейство и типоразмер: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тип: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная
Стадии - Стадия возведения: Стадия 1
Name (КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200:Муфта соединительная:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | D2 (mm) | D3 (mm) | DN (mm) | Dвн (mm) | L (mm) | L2 (mm) | Объем (m3) | Размер | ADSK_Масса | Вариант конструкции
525977 | 015050 | Муфта для двустенных-дренажных труб 50мм | 51 | 60 | 50 | 53 | 95 | 9.5 | 0.000214986 | 50 ммøx50 ммø | 0.03
526109 | 015063 | Муфта для двустенных-дренажных труб 63мм | 64 | 72 | 63 | 66 | 104 | 10.4 | 0.000362183 | 63 ммøx63 ммø | 0.04
526124 | 015075 | Муфта для двустенных-дренажных труб 75мм | 76 | 82 | 75 | 78 | 150 | 15 | 0.000723695 | 75 ммøx75 ммø | 0.07 | Главная модель
526128 | 015090 | Муфта для двустенных-дренажных труб 90мм | 92 | 102 | 90 | 94 | 148 | 14.8 | 0.00104463 | 90 ммøx90 ммø | 0.15 | Главная модель
526132 | 015110 | Муфта для двустенных-дренажных труб 110мм | 111 | 123 | 110 | 113 | 200 | 20 | 0.00204145 | 110 ммøx110 ммø | 0.18 | Главная модель
526136 | 015125 | Муфта для двустенных-дренажных труб 125мм | 126 | 135 | 125 | 128 | 200 | 20 | 0.00260165 | 125 ммøx125 ммø | 0.3 | Главная модель
526140 | 015140 | Муфта для двустенных-дренажных труб 140мм | 141 | 150 | 140 | 143 | 200 | 20 | 0.00324333 | 140 ммøx140 ммø | 0.23 | Главная модель
526144 | 015160 | Муфта для двустенных-дренажных труб 160мм | 164 | 172 | 160 | 166 | 200 | 20 | 0.00435959 | 160 ммøx160 ммø | 0.35
526148 | 015200 | Муфта для двустенных-дренажных труб 200мм | 202 | 214 | 200 | 204 | 242 | 24.2 | 0.00798792 | 200 ммøx200 ммø | 0.49 | Главная модель
