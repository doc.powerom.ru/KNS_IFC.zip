Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:18:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:18:01 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{A1E7A86E-412E-4056-A5CE-E28115572A70}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:18:00 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:18:00 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:18:00 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (7)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | Труба ПП гибкая гофр. д.16-50мм, лёгкая с протяжкой, 15-100м, цвет синий
300 | д.16мм | Идентификация - Вариант конструкции: Главная модель
300 | д.20мм
300 | д.25мм
300 | д.32мм
300 | д.40мм | Идентификация - Вариант конструкции: Главная модель
300 | д.50мм

# IfcDistributionPort (24)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_698294
2 x OutPort_698313
InPort_698300
InPort_698333
2 x OutPort_698353
InPort_698339
InPort_698373
2 x OutPort_698393
InPort_698379
InPort_698416
2 x OutPort_698436
InPort_698422
InPort_698459
2 x OutPort_698479
InPort_698465
InPort_698499
2 x OutPort_698519
InPort_698505

# IfcFlowFitting: Неспецифицируемый_синий (6)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Синий
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Синий; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_синий; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_синий
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_синий; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_синий; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_синий; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_синий
Размеры - Длина короба: 1 mm; Радиус загиба: 5 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_синий:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
698313 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø | Идентификация - Вариант конструкции: Главная модель
698353 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
698393 | 15.675 | 25 | 12.5 | 0.00000702465 | 7.4928 | 25 ммøx25 ммø
698436 | 19.175 | 32 | 16 | 0.0000137199 | 8.94255 | 32 ммøx32 ммø
698479 | 23.175 | 40 | 20 | 0.000025385 | 10.5994 | 40 ммøx40 ммø
698519 | 28.175 | 50 | 25 | 0.0000473744 | 12.6705 | 50 ммøx50 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПП гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет синий (12)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПП гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет синий; Семейство: Короб без соединительных деталей: КНС_Труба ПП гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет синий; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПП гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет синий; Тип: Короб без соединительных деталей: КНС_Труба ПП гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет синий; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПП д.16-50мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПП гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет синий
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_синий; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-010-47022248-2003; ADSK_Материал: DKC_Пластик_Полипропилен_Синий; ADSK_Наименование: Труба ПП гибкая гофр. д.16-50мм, лёгкая с протяжкой, 15-100м, цвет синий; ADSK_Наименование краткое: Труба ПП гибкая гофр. д.16-50мм, лёгкая с протяжкой, 15-100м, цвет синий; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1241 (легкая серия); DKC_Кол-во в бухте L_м: д.16=100 / д.20=100 / д.25=50 / д.32=25 / д.40=20 / д.50=15; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 120 H на 5 см (легкая серия)*; свыше 320 Н на 5 см (тяжелая серия)*; свыше 450 Н на 5 см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –25 до + 60 °С; DKC_Температура эксплуатации: от –40 до +105 °С (при отсутствии механических воздействий); Тип трубопровода: 11916
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПП гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет синий; Комментарии к типоразмеру: Гофрированная труба из полипропилена (серия 10)
Name (Короб без соединительных деталей:КНС_Труба ПП гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет синий:...) | Вариант конструкции | sets with these values | Внешний диаметр (mm) | Внутренний диаметр (mm) | Диаметр (Размер по каталогу) (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
698294 | Главная модель | 2 | 15.8 | 11.2 | 16 | 1994.37 | 16 ммø | 7.9 | -7.9
698300 |  |  | 15.8 | 11.2 | 16 | 614.371 | 16 ммø | 7.9 | -7.9
698333 |  |  | 19.7 | 14.8 | 20 | 1993.54 | 20 ммø | 9.85 | -9.85
698339 | Главная модель | 2 | 19.7 | 14.8 | 20 | 613.543 | 20 ммø | 9.85 | -9.85
698373 |  |  | 25 | 19 | 25 | 1992.51 | 25 ммø | 12.5 | -12.5
698379 | Главная модель | 2 | 25 | 19 | 25 | 612.507 | 25 ммø | 12.5 | -12.5
698416 | Главная модель | 2 | 31.4 | 24.2 | 32 | 1991.06 | 32 ммø | 15.7 | -15.7
698422 |  |  | 31.4 | 24.2 | 32 | 611.057 | 32 ммø | 15.7 | -15.7
698459 | Главная модель | 2 | 39.2 | 30.8 | 40 | 1989.4 | 40 ммø | 19.6 | -19.6
698465 | Главная модель | 2 | 39.2 | 30.8 | 40 | 609.401 | 40 ммø | 19.6 | -19.6
698499 |  |  | 49 | 39.7 | 50 | 1987.33 | 50 ммø | 24.5 | -24.5
698505 | Главная модель | 2 | 49 | 39.7 | 50 | 607.33 | 50 ммø | 24.5 | -24.5
