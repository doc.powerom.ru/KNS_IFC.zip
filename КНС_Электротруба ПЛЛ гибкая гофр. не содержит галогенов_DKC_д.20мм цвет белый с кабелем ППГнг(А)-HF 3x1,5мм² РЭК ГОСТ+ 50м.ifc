Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:11:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:11:18 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9A18B544-12CB-46B5-8B1D-2E8F7D528922}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:11:17 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:11:17 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:11:17 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300 (5)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.20мм 3x1,5мм² | Главная модель
300 | Электротруба ПЛЛ гибкая гофр. не содержит галогенов д.20/25мм, цвет белый, с кабелем ППГнг(А)-HF 3x1,5мм²/3x2,5мм² РЭК "ГОСТ+", 50м | Главная модель
300 | д.20мм 3x2,5мм² | Главная модель
300 | д.25мм 3x2,5мм² | Главная модель
300 | д.25мм 3x1,5мм²

# IfcDistributionPort (16)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_690707
2 x OutPort_690721
InPort_690713
InPort_691187
2 x OutPort_691205
InPort_691197
InPort_691225
2 x OutPort_691241
InPort_691233
InPort_691262
2 x OutPort_691278
InPort_691270

# IfcFlowFitting: Неспецифицируемый_белый (4)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Белый
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Белый; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_белый; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_белый
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_белый; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_белый; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_белый; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_белый
Размеры - Длина короба: 1 mm; Радиус загиба: 5 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_белый:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
690721 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
691205 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
691241 | 15.675 | 25 | 12.5 | 0.00000702465 | 7.4928 | 25 ммøx25 ммø | Идентификация - Вариант конструкции: Главная модель
691278 | 15.675 | 25 | 12.5 | 0.00000702465 | 7.4928 | 25 ммøx25 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x1,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x1,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x1,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x1,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x1,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 19.7 mm; Внутренний диаметр: 19.1 mm; Диаметр (Размер по каталогу): 20 mm; Размер: 20 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 9.85 mm; Нижняя отметка: -9.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПЛЛ д.20мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x1,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-052-47022248-2016; ADSK_Материал: DKC_Композиция на полиолефиновой основе_Белый; ADSK_Наименование: Электротруба ПЛЛ гибкая гофр. не содержит галогенов д.20мм, цвет белый, с кабелем ППГнг(А)-HF 3x1,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПЛЛ гибкая гофр. не содержит галогенов д.20мм, цвет белый, с кабелем ППГнг(А)-HF 3x1,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1132; DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 2; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H; DKC_Разрывная прочность: не менее 200 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –15 до +90 °С; DKC_Температура эксплуатации: от –15 до +90 °С; DKC_Тип кабеля: ППГнг(А)-HF 3x1,5 мм²; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж; Тип трубопровода: 82050
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x1,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПЛЛ без содержания галогенов
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_белый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x1,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
690707 | 1993.54 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
690713 | 613.543

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x2,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x2,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x2,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x2,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x2,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 19.7 mm; Внутренний диаметр: 19.1 mm; Диаметр (Размер по каталогу): 20 mm; Размер: 20 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 9.85 mm; Нижняя отметка: -9.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПЛЛ д.20мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x2,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Материал: DKC_Композиция на полиолефиновой основе_Белый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-052-47022248-2016; ADSK_Наименование: Электротруба ПЛЛ гибкая гофр. не содержит галогенов д.20мм, цвет белый, с кабелем ППГнг(А)-HF 3x2,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПЛЛ гибкая гофр. не содержит галогенов д.20мм, цвет белый, с кабелем ППГнг(А)-HF 3x2,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1132; DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 2; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H; DKC_Разрывная прочность: не менее 200 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –15 до +90 °С; DKC_Температура эксплуатации: от –15 до +90 °С; DKC_Тип кабеля: ППГнг(А)-HF 3x2,5 мм²; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж; Тип трубопровода: 82051
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x2,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПЛЛ без содержания галогенов
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_белый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.20мм цвет белый с кабелем ППГнг(А)-HF 3x2,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
691187 | 1993.54
691197 | 613.543 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x1,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x1,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x1,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x1,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x1,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 24.7 mm; Внутренний диаметр: 24.3 mm; Диаметр (Размер по каталогу): 25 mm; Размер: 25 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 12.35 mm; Нижняя отметка: -12.35 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПЛЛ д.25мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x1,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Материал: DKC_Композиция на полиолефиновой основе_Белый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-052-47022248-2016; ADSK_Наименование: Электротруба ПЛЛ гибкая гофр. не содержит галогенов д.25мм, цвет белый, с кабелем ППГнг(А)-FRHF 3x1,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПЛЛ гибкая гофр. не содержит галогенов д.25мм, цвет белый, с кабелем ППГнг(А)-FRHF 3x1,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1132; DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 2; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H; DKC_Разрывная прочность: не менее 200 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –15 до +90 °С; DKC_Температура эксплуатации: от –15 до +90 °С; DKC_Тип кабеля: ППГнг(А)-FRHF 3x1,5 мм²; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж; Тип трубопровода: 82052
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x1,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПЛЛ без содержания галогенов
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_белый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x1,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
691225 | 1992.51
691233 | 612.507

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x2,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x2,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x2,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x2,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x2,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 24.7 mm; Внутренний диаметр: 24.3 mm; Диаметр (Размер по каталогу): 25 mm; Размер: 25 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 12.35 mm; Нижняя отметка: -12.35 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПЛЛ д.25мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x2,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Материал: DKC_Композиция на полиолефиновой основе_Белый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-052-47022248-2016; ADSK_Наименование: Электротруба ПЛЛ гибкая гофр. не содержит галогенов д.25мм, цвет белый, с кабелем ППГнг(А)-FRHF 3x2,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПЛЛ гибкая гофр. не содержит галогенов д.25мм, цвет белый, с кабелем ППГнг(А)-FRHF 3x2,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1132; DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 2; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H; DKC_Разрывная прочность: не менее 200 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –15 до +90 °С; DKC_Температура эксплуатации: от –15 до +90 °С; DKC_Тип кабеля: ППГнг(А)-FRHF 3x2,5мм²; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж; Тип трубопровода: 82053
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x2,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПЛЛ без содержания галогенов
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_белый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПЛЛ гибкая гофр. не содержит галогенов_DKC_д.25мм цвет белый с кабелем ППГнг(А)-FRHF 3x2,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
691262 | 1992.51
691270 | 612.507 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
