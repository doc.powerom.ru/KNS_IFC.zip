Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:09:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:09:13 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{38114BFB-877A-4F8A-8C0A-39B3907E4882}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:09:12 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:09:13 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:09:13 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (10)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | 55
300 | 65 | Главная модель
300 | 95 | Главная модель
300 | 105 | Главная модель
300 | 135 | Главная модель
300 | 145
300 | Крюк изолированный для коробки потолочной | Главная модель
300 | 155 | Главная модель
300 | 75
300 | 115 | Главная модель

# IfcFlowFitting: 105мм, КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC:105мм:760447
In: Этаж 01
Type - Material: DKC_Сталь
Type - Данные - ADSK_Материал: DKC_Сталь; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59105; ADSK_Наименование: Крюк изолированный для коробки потолочной, 105мм
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59105/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 105мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: подвес люстры к залитой в бетон коробке потолочной
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC
Type - Размеры - ADSK_Размер_Длина: 105 mm
Type - Текст - ADSK_Масса: 0.04494
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 105мм
Данные - ADSK_Наименование краткое: Крюк изолированный для коробки потолочной, 105мм
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 105мм; Семейство: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 105мм; Семейство и типоразмер: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 105мм; Тип: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 105мм
Размеры - Объем: 0.00000577411 m3; Площадь: 0.00195294 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 115мм, КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC:115мм:760446
In: Этаж 01
Type - Material: DKC_Сталь
Type - Данные - ADSK_Материал: DKC_Сталь; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59115; ADSK_Наименование: Крюк изолированный для коробки потолочной, 115мм
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59115/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 115мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: подвес люстры к залитой в бетон коробке потолочной
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC
Type - Размеры - ADSK_Размер_Длина: 115 mm
Type - Текст - ADSK_Масса: 0.046
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 115мм
Данные - ADSK_Наименование краткое: Крюк изолированный для коробки потолочной, 115мм
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 115мм; Семейство: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 115мм; Семейство и типоразмер: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 115мм; Тип: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 115мм
Размеры - Объем: 0.00000605686 m3; Площадь: 0.00204719 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 135мм, КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC:135мм:760445
In: Этаж 01
Type - Material: DKC_Сталь
Type - Данные - ADSK_Материал: DKC_Сталь; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59135; ADSK_Наименование: Крюк изолированный для коробки потолочной, 135мм
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59135/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 135мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: подвес люстры к залитой в бетон коробке потолочной
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC
Type - Размеры - ADSK_Размер_Длина: 135 mm
Type - Текст - ADSK_Масса: 0.05
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 135мм
Данные - ADSK_Наименование краткое: Крюк изолированный для коробки потолочной, 135мм
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 135мм; Семейство: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 135мм; Семейство и типоразмер: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 135мм; Тип: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 135мм
Размеры - Объем: 0.00000662236 m3; Площадь: 0.00223568 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 145мм, КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC:145мм:760444
In: Этаж 01
Type - Material: DKC_Сталь
Type - Данные - ADSK_Материал: DKC_Сталь; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59145; ADSK_Наименование: Крюк изолированный для коробки потолочной, 145мм
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59145/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 145мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: подвес люстры к залитой в бетон коробке потолочной
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC
Type - Размеры - ADSK_Размер_Длина: 145 mm
Type - Текст - ADSK_Масса: 0.036
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 145мм
Данные - ADSK_Наименование краткое: Крюк изолированный для коробки потолочной, 145мм
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 145мм; Семейство: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 145мм; Семейство и типоразмер: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 145мм; Тип: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 145мм
Размеры - Объем: 0.00000690511 m3; Площадь: 0.00232993 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 155мм, КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC:155мм:760443
In: Этаж 01
Type - Material: DKC_Сталь
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59155; ADSK_Материал: DKC_Сталь; ADSK_Наименование: Крюк изолированный для коробки потолочной, 155мм
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59155/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 155мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: подвес люстры к залитой в бетон коробке потолочной
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC
Type - Размеры - ADSK_Размер_Длина: 155 mm
Type - Текст - ADSK_Масса: 0.038
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 155мм
Данные - ADSK_Наименование краткое: Крюк изолированный для коробки потолочной, 155мм
Зависимости - Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 155мм; Семейство: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 155мм; Семейство и типоразмер: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 155мм; Тип: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 155мм
Размеры - Объем: 0.00000718786 m3; Площадь: 0.00242418 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 55мм, КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC:55мм:760451
In: Этаж 01
Type - Material: DKC_Сталь
Type - Данные - ADSK_Материал: DKC_Сталь; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59055; ADSK_Наименование: Крюк изолированный для коробки потолочной, 55мм
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59055/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 55мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: подвес люстры к залитой в бетон коробке потолочной
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC
Type - Размеры - ADSK_Размер_Длина: 55 mm
Type - Текст - ADSK_Масса: 0.03
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 55мм
Данные - ADSK_Наименование краткое: Крюк изолированный для коробки потолочной, 55мм
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 55мм; Семейство: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 55мм; Семейство и типоразмер: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 55мм; Тип: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 55мм
Размеры - Объем: 0.00000436035 m3; Площадь: 0.0014817 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 65мм, КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC:65мм:760450
In: Этаж 01
Type - Material: DKC_Сталь
Type - Данные - ADSK_Материал: DKC_Сталь; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59065; ADSK_Наименование: Крюк изолированный для коробки потолочной, 65мм
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59065/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 65мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: подвес люстры к залитой в бетон коробке потолочной
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC
Type - Размеры - ADSK_Размер_Длина: 65 mm
Type - Текст - ADSK_Масса: 0.036
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 65мм
Данные - ADSK_Наименование краткое: Крюк изолированный для коробки потолочной, 65мм
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 65мм; Семейство: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 65мм; Семейство и типоразмер: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 65мм; Тип: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 65мм
Размеры - Объем: 0.0000046431 m3; Площадь: 0.00157595 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 75мм, КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC:75мм:760449
In: Этаж 01
Type - Material: DKC_Сталь
Type - Данные - ADSK_Материал: DKC_Сталь; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59075; ADSK_Наименование: Крюк изолированный для коробки потолочной, 75мм
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59075/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 75мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: подвес люстры к залитой в бетон коробке потолочной
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC
Type - Размеры - ADSK_Размер_Длина: 75 mm
Type - Текст - ADSK_Масса: 0.04
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 75мм
Данные - ADSK_Наименование краткое: Крюк изолированный для коробки потолочной, 75мм
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 75мм; Семейство: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 75мм; Семейство и типоразмер: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 75мм; Тип: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 75мм
Размеры - Объем: 0.00000492585 m3; Площадь: 0.00167019 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 95мм, КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC:95мм:760448
In: Этаж 01
Type - Material: DKC_Сталь
Type - Данные - ADSK_Материал: DKC_Сталь; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59095; ADSK_Наименование: Крюк изолированный для коробки потолочной, 95мм
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59095/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 95мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: подвес люстры к залитой в бетон коробке потолочной
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC
Type - Размеры - ADSK_Размер_Длина: 95 mm
Type - Текст - ADSK_Масса: 0.04275
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 95мм
Данные - ADSK_Наименование краткое: Крюк изолированный для коробки потолочной, 95мм
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 95мм; Семейство: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 95мм; Семейство и типоразмер: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 95мм; Тип: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 95мм
Размеры - Объем: 0.00000549136 m3; Площадь: 0.00185869 m2
Стадии - Стадия возведения: Стадия 1
