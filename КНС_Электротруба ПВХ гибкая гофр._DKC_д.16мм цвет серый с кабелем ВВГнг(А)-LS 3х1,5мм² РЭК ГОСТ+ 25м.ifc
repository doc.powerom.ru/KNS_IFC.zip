Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:11:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:11:42 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{61DE7AAD-A367-4AED-84A7-DF275AC86B9C}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:11:40 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:11:41 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:11:41 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300 (9)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.16мм 3x1,5мм² 25м
300 | Электротруба ПВХ гибкая гофр. д.16/20мм, цвет серый, с кабелем ВВГнг(А)-LS 3х1,5мм²/3х2,5мм² РЭК ГОСТ+, 25/50/100м | Идентификация - Вариант конструкции: Главная модель
300 | д.16мм 3x1,5мм² 50м
300 | д.20мм 3x1,5мм² 100м | Идентификация - Вариант конструкции: Главная модель
300 | д.16мм 3x1,5мм² 100м
300 | д.16мм 3x2,5мм² 25м | Идентификация - Вариант конструкции: Главная модель
300 | д.16мм 3x2,5мм² 50м
300 | д.20мм 3x2,5мм² 100м
300 | д.20мм 3x2,5мм² 50м

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_692278
2 x OutPort_692292
InPort_692284
InPort_692312
2 x OutPort_692326
InPort_692318
InPort_692346
2 x OutPort_692360
InPort_692352
InPort_692383
2 x OutPort_692403
InPort_692389
InPort_692446
2 x OutPort_692460
InPort_692452
InPort_692483
2 x OutPort_692497
InPort_692489
InPort_692517
2 x OutPort_692531
InPort_692523
InPort_692551
2 x OutPort_692565
InPort_692557

# IfcFlowFitting: Неспецифицируемый_серый (8)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Серый
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Серый; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_серый; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_серый
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый
Размеры - Длина короба: 1 mm; Радиус загиба: 5 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_серый:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
692292 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø | Идентификация - Вариант конструкции: Главная модель
692326 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
692360 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø | Идентификация - Вариант конструкции: Главная модель
692403 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
692460 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø | Идентификация - Вариант конструкции: Главная модель
692497 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
692531 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
692565 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м (4)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Тип: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16/20мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Электротруба ПВХ гибкая гофр. д.16-20мм, цвет серый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 100м; ADSK_Наименование краткое: Электротруба ПВХ гибкая гофр. д.16-20мм, цвет серый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 100м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); DKC_Кол-во в бухте L_м: 100; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия); DKC_Разрывная прочность: не менее 100 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Тип кабеля: ВВГнг(А)-LS 3х1,5; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; Тип трубопровода: 916100
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Комментарии к типоразмеру: Гофрированная электротруба из ПВХ
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
692346 | 16 | 11.5 | 1994.37 | 16 ммø | 8 | -8
692352 | 16 | 11.5 | 614.371 | 16 ммø | 8 | -8 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
692383 | 20 | 14.9 | 1993.54 | 20 ммø | 10 | -10
692389 | 20 | 14.9 | 613.543 | 20 ммø | 10 | -10

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м (4)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16/20мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Электротруба ПВХ гибкая гофр. д.16-20мм, цвет серый, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПВХ гибкая гофр. д.16-20мм, цвет серый, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия); DKC_Разрывная прочность: не менее 100 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Тип кабеля: ВВГнг(А)-LS 3х2,5; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; Тип трубопровода: 91651
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПВХ
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16-20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
692483 | 16 | 11.5 | 1994.37 | 16 ммø | 8 | -8
692489 | 16 | 11.5 | 614.371 | 16 ммø | 8 | -8
692517 | 20 | 14.9 | 1993.54 | 20 ммø | 10 | -10 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
692523 | 20 | 14.9 | 613.543 | 20 ммø | 10 | -10

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Тип: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 16 mm; Внутренний диаметр: 11.5 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 8 mm; Нижняя отметка: -8 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Материал: DKC_ПВХ_Серый; ADSK_Наименование: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 25м; ADSK_Наименование краткое: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 25м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); DKC_Кол-во в бухте L_м: 25; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия); DKC_Разрывная прочность: не менее 100 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Тип кабеля: ВВГнг(А)-LS 3х1,5; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; Тип трубопровода: 91625
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Комментарии к типоразмеру: Гофрированная электротруба из ПВХ
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м:...) | Длина (mm)
692278 | 1994.37
692284 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Идентификация - Вариант конструкции: Главная модель; sets with these values: 2; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПВХ
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 16 mm; Внутренний диаметр: 11.5 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 8 mm; Нижняя отметка: -8 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия); DKC_Разрывная прочность: не менее 100 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Тип кабеля: ВВГнг(А)-LS 3х1,5; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; Тип трубопровода: 91650
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
692312 | 1994.37
692318 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Тип: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 16 mm; Внутренний диаметр: 11.5 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 8 mm; Нижняя отметка: -8 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 25м; ADSK_Наименование краткое: Электротруба ПВХ гибкая гофр. д.16мм, цвет серый, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 25м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); DKC_Кол-во в бухте L_м: 25; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия); DKC_Разрывная прочность: не менее 100 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Тип кабеля: ВВГнг(А)-LS 3х2,5; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; Тип трубопровода: 91626
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Комментарии к типоразмеру: Гофрированная электротруба из ПВХ
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.16мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м:...) | Длина (mm)
692446 | 1994.37
692452 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Тип: Короб без соединительных деталей: КНС_Электротруба ПВХ гибкая гофр._DKC_д.20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 20 mm; Внутренний диаметр: 14.9 mm; Диаметр (Размер по каталогу): 20 mm; Размер: 20 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 10 mm; Нижняя отметка: -10 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.20мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПВХ гибкая гофр._DKC_д.20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м
Данные - ADSK_Материал: DKC_ПВХ_Серый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Наименование: Электротруба ПВХ гибкая гофр. д.20мм, цвет серый, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 100м; ADSK_Наименование краткое: Электротруба ПВХ гибкая гофр. д.20мм, цвет серый, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 100м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); DKC_Кол-во в бухте L_м: 100; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия); DKC_Разрывная прочность: не менее 100 Н; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Тип кабеля: ВВГнг(А)-LS 3х2,5; DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; Тип трубопровода: 91625
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПВХ гибкая гофр._DKC_д.20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Комментарии к типоразмеру: Гофрированная электротруба из ПВХ
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПВХ гибкая гофр._DKC_д.20мм цвет серый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м:...) | Длина (mm)
692551 | 1993.54
692557 | 613.543 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
