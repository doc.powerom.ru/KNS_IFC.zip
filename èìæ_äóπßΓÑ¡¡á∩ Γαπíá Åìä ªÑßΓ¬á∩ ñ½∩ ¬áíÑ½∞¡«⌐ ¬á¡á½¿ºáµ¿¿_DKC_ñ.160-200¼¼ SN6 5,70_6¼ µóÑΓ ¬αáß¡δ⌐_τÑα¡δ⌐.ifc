Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T16:09:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 16:09:02 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{81E181A8-AC94-45F9-824C-6AFC6D5CFA54}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 16:09:00 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 16:09:00 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 16:09:00 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (5)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.160мм 6м | Лого (основной)
300 | д.200мм 6м | Лого : Лого
300 | Двустенная труба ПНД жесткая для кабельной канализации, д.160-200мм, SN6, 5,70/6м, цвет красный/черный | Лого (основной)
300 | д.160мм 5,70м | Главная модель
300 | д.200мм 5,70м | Главная модель

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_524313
2 x OutPort_524315
InPort_524314
InPort_524318
2 x OutPort_524320
InPort_524319
InPort_563710
2 x OutPort_563712
InPort_563711
InPort_563714
2 x OutPort_563716
InPort_563715
InPort_563920
2 x OutPort_563922
InPort_563921
InPort_563924
2 x OutPort_563926
InPort_563925
InPort_563960
2 x OutPort_563962
InPort_563961
InPort_563964
2 x OutPort_563966
InPort_563965

# IfcFlowFitting: Неспецифицируемый_красный (4)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Красный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Красный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_красный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_красный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный
Размеры - Длина короба: 1 mm; Радиус загиба: 10 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_красный:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
524315 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø
524320 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø
563922 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø | Идентификация - Вариант конструкции: Главная модель
563926 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø | Идентификация - Вариант конструкции: Главная модель

# IfcFlowFitting: Неспецифицируемый_черный (4)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Черный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Черный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_черный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_черный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Размеры - Угол: 45 deg; Длина короба: 1 mm; Радиус загиба: 10 mm
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_черный:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
563712 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø | Идентификация - Вариант конструкции: Главная модель
563716 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø
563962 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø
563966 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет красный (4)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет красный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет красный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет красный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет красный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД жесткая для кабельной канализации SN6
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет красный
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Красный; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-019-47022248-2008; ADSK_Наименование: Двустенная труба ПНД жесткая для кабельной канализации, д.160-200мм, SN6, 5,70м, цвет красный; ADSK_Наименование краткое: Двустенная труба ПНД жесткая для кабельной канализации, д.160-200мм, SN6, 5,70м, цвет красный; DKC_Длина отрезков L_м: 5.7; DKC_Исполнение: Исполнение 2 – специальное исполнение для контейнерной отправки. Длина отрезков трубы 5,70 м, соединительная муфта одета на торец трубы; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кольцевая жесткость_кПа: д.160 SN6=6 / д.200 SN6=6; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –40 до + 90 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или замоноличено внутри бетонных (ж/б) изделий). Рекомендуется использовать на участках с высокой нагрузкой (под автомобильными и ж/д дорогами и т. п.), при блочной укладке труб, при укладке в трубах тяжелого кабеля.; Тип трубопровода: 160916
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/188/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет красный; Комментарии к типоразмеру: Жесткие двустенные гофрированные трубы
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет красный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
563920 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
563921 | 160 | 137 | 964.548 | 160 ммø | 80 | -80
563924 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
563925 | 200 | 172 | 956.264 | 200 ммø | 100 | -100 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет черный (4)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет черный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет черный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет черный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД жесткая для кабельной канализации SN6
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет черный
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Красный; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-019-47022248-2008; ADSK_Наименование: Двустенная труба ПНД жесткая для кабельной канализации, д.160-200мм, SN6, 5,70м, цвет черный; ADSK_Наименование краткое: Двустенная труба ПНД жесткая для кабельной канализации, д.160-200мм, SN6, 5,70м, цвет черный; DKC_Длина отрезков L_м: 5.7; DKC_Исполнение: Исполнение 2 – специальное исполнение для контейнерной отправки. Длина отрезков трубы 5,70 м, соединительная муфта одета на торец трубы; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кольцевая жесткость_кПа: д.160 SN6=6 / д.200 SN6=6; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –40 до + 90 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или замоноличено внутри бетонных (ж/б) изделий). Рекомендуется использовать на участках с высокой нагрузкой (под автомобильными и ж/д дорогами и т. п.), при блочной укладке труб, при укладке в трубах тяжелого кабеля.; Тип трубопровода: 160918
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/188/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет черный; Комментарии к типоразмеру: Жесткие двустенные гофрированные трубы
Соединительные детали - Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 5,70м цвет черный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
563960 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80
563961 | 160 | 137 | 964.548 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
563964 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
563965 | 200 | 172 | 956.264 | 200 ммø | 100 | -100

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет красный (4)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет красный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет красный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет красный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет красный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД жесткая для кабельной канализации SN6
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет красный
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-019-47022248-2008; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Красный; ADSK_Наименование: Двустенная труба ПНД жесткая для кабельной канализации, д.160-200мм, SN6, 6м, цвет красный; ADSK_Наименование краткое: Двустенная труба ПНД жесткая для кабельной канализации, д.160-200мм, SN6, 6м, цвет красный; DKC_Длина отрезков L_м: 6; DKC_Исполнение: Исполнение 1 – стандартное исполнение отрезков трубы по 6 м, соединительная муфта одета на торец отрезка трубы; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кольцевая жесткость_кПа: д.160 SN6=6 / д.200 SN6=6; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –40 до + 90 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или замоноличено внутри бетонных (ж/б) изделий). Рекомендуется использовать на участках с высокой нагрузкой (под автомобильными и ж/д дорогами и т. п.), при блочной укладке труб, при укладке в трубах тяжелого кабеля.; Тип трубопровода: 160912
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/188/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет красный; Комментарии к типоразмеру: Жесткие двустенные гофрированные трубы
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет красный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
524313 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
524314 | 160 | 137 | 964.548 | 160 ммø | 80 | -80
524318 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
524319 | 200 | 172 | 956.264 | 200 ммø | 100 | -100

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет черный (4)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет черный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет черный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет черный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД жесткая для кабельной канализации SN6
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет черный
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Красный; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-019-47022248-2008; ADSK_Наименование: Двустенная труба ПНД жесткая для кабельной канализации, д.160-200мм, SN6, 6м, цвет черный; ADSK_Наименование краткое: Двустенная труба ПНД жесткая для кабельной канализации, д.160-200мм, SN6, 6м, цвет черный; DKC_Длина отрезков L_м: 6; DKC_Исполнение: Исполнение 1 – стандартное исполнение отрезков трубы по 6 м, соединительная муфта одета на торец отрезка трубы; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кольцевая жесткость_кПа: д.160 SN6=6 / д.200 SN6=6; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –40 до + 90 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или замоноличено внутри бетонных (ж/б) изделий). Рекомендуется использовать на участках с высокой нагрузкой (под автомобильными и ж/д дорогами и т. п.), при блочной укладке труб, при укладке в трубах тяжелого кабеля.; Тип трубопровода: 160914
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/188/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет черный; Комментарии к типоразмеру: Жесткие двустенные гофрированные трубы
Соединительные детали - Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для кабельной канализации_DKC_д.160-200мм SN6 6м цвет черный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
563710 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
563711 | 160 | 137 | 964.548 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
563714 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
563715 | 200 | 172 | 956.264 | 200 ммø | 100 | -100
