Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:06:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:06:43 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{6D84A16E-C265-412E-A6DD-BF8AC9AC4A68}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:06:42 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:06:42 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:06:42 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300 (4)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | D70х57 | Идентификация - Вариант конструкции: Главная модель
300 | Коробка установочная для заливки в бетон
300 | D70х97
300 | D70х137

# IfcFlowFitting: D70х137, КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х137:D70х137:753996
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Синий, DKC_Пластик_Полипропилен_Красный
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен_Красный; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59382; ADSK_Наименование: Коробка установочная для заливки в бетон, д.70х136мм; ADSK_Примечание: фланцевая крышка – 1 шт.; днище – 1 шт.; корпус –3 шт.; DKC_Температура эксплуатации: от –25 до +100 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59382/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: D70х137; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: формирование посадочных мест под электроустановочные изделия европейского стандарта при монолитном бетоностроении
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х137
Type - Размеры - ADSK_Размер_Длина: 137 mm; DN: 20 mm; DN2: 25 mm
Type - Текст - ADSK_Масса: 0.095
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D70х137
Графика - Использовать масштаб аннотаций: no
Данные - ADSK_Наименование краткое: Коробка установочная для заливки в бетон, д.70х136мм
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х137: D70х137; Семейство: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х137: D70х137; Семейство и типоразмер: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х137: D70х137; Тип: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х137: D70х137
Размеры - Объем: 0.000495239 m3; Площадь: 0.0346052 m2; Размер: 25 ммøx25 ммøx25 ммøx25 ммøx25 ммøx25 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммø
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: D70х57, КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х57:D70х57:753768
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Синий, DKC_Пластик_Полипропилен_Красный
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59380; ADSK_Материал: DKC_Пластик_Полипропилен_Красный; ADSK_Наименование: Коробка установочная для заливки в бетон, д.70х57мм; ADSK_Примечание: фланцевая крышка – 1 шт.; днище – 1 шт.; корпус – 1 шт.; DKC_Температура эксплуатации: от –25 до +100 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59380/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: D70х57; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: формирование посадочных мест под электроустановочные изделия европейского стандарта при монолитном бетоностроении
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х57
Type - Размеры - ADSK_Размер_Длина: 57 mm; DN: 20 mm; DN2: 25 mm
Type - Текст - ADSK_Масса: 0.04
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D70х57
Графика - Использовать масштаб аннотаций: no
Данные - ADSK_Наименование краткое: Коробка установочная для заливки в бетон, д.70х57мм
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х57: D70х57; Семейство: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х57: D70х57; Семейство и типоразмер: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х57: D70х57; Тип: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х57: D70х57
Размеры - Объем: 0.000217154 m3; Площадь: 0.0189131 m2; Размер: 25 ммøx25 ммøx20 ммøx20 ммøx20 ммøx20 ммø
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: D70х97, КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х97:D70х97:753965
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Синий, DKC_Пластик_Полипропилен_Красный
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен_Красный; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59381; ADSK_Наименование: Коробка установочная для заливки в бетон, д.70х100мм; ADSK_Примечание: фланцевая крышка – 1 шт.; днище – 1 шт.; корпус –2 шт.; DKC_Температура эксплуатации: от –25 до +100 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59381/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: D70х97; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: формирование посадочных мест под электроустановочные изделия европейского стандарта при монолитном бетоностроении
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х97
Type - Размеры - ADSK_Размер_Длина: 97 mm; DN: 20 mm; DN2: 25 mm
Type - Текст - ADSK_Масса: 0.074
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: D70х97
Графика - Использовать масштаб аннотаций: no
Данные - ADSK_Наименование краткое: Коробка установочная для заливки в бетон, д.70х100мм
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х97: D70х97; Семейство: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х97: D70х97; Семейство и типоразмер: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х97: D70х97; Тип: КНС_КоробкаУстановочнаяДляЗаливкиВБетон_DKC_D70х97: D70х97
Размеры - Объем: 0.000356197 m3; Площадь: 0.0267591 m2; Размер: 25 ммøx25 ммøx25 ммøx25 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммø
Стадии - Стадия возведения: Стадия 1
