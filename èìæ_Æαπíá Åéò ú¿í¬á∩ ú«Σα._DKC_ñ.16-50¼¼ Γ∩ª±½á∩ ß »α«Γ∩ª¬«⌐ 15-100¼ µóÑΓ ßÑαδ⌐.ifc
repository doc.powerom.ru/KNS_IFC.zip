Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:14:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:14:49 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{27FE26D6-33C5-4DD6-9258-1F0823672C3E}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:14:48 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:14:48 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:14:48 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (7)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.16мм 100м | Главная модель
300 | Труба ПВХ гибкая гофр. д.16/20/25/32/40/50мм, тяжелая с протяжкой, 15/25/50/100м, цвет серый | Главная модель
300 | д.20мм 100м
300 | д.25мм 50м | Главная модель
300 | д.32мм 25м | Главная модель
300 | д.40мм 20м
300 | д.50мм 15м

# IfcDistributionPort (24)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_695118
2 x OutPort_695134
InPort_695126
InPort_695157
2 x OutPort_695171
InPort_695163
InPort_695191
2 x OutPort_695205
InPort_695197
InPort_695228
2 x OutPort_695242
InPort_695234
InPort_695265
2 x OutPort_695279
InPort_695271
InPort_695302
2 x OutPort_695316
InPort_695308

# IfcFlowFitting: Неспецифицируемый_серый (6)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Серый
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Серый; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_серый; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_серый
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый
Размеры - Длина короба: 1 mm; Радиус загиба: 5 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_серый:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер | Вариант конструкции
695134 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
695171 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø | Главная модель
695205 | 15.675 | 25 | 12.5 | 0.00000702465 | 7.4928 | 25 ммøx25 ммø | Главная модель
695242 | 19.175 | 32 | 16 | 0.0000137199 | 8.94255 | 32 ммøx32 ммø
695279 | 23.175 | 40 | 20 | 0.000025385 | 10.5994 | 40 ммøx40 ммø | Главная модель
695316 | 28.175 | 50 | 25 | 0.0000473744 | 12.6705 | 50 ммøx50 ммø | Главная модель

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16-50мм тяжёлая с протяжкой 15-100м цвет серый (12)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-50мм тяжёлая с протяжкой 15-100м цвет серый; Семейство: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-50мм тяжёлая с протяжкой 15-100м цвет серый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-50мм тяжёлая с протяжкой 15-100м цвет серый; Тип: Короб без соединительных деталей: КНС_Труба ПВХ гибкая гофр._DKC_д.16-50мм тяжёлая с протяжкой 15-100м цвет серый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПВХ д.16-50мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПВХ гибкая гофр._DKC_д.16-50мм тяжёлая с протяжкой 15-100м цвет серый
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_серый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2247-008-47022248-2002; ADSK_Материал: DKC_ПВХ_Серый; ADSK_Наименование: Труба ПВХ гибкая гофр. д.16-50мм, тяжёлая с протяжкой, 15-100м, цвет серый; ADSK_Наименование краткое: Труба ПВХ гибкая гофр. д.16-50мм, тяжёлая с протяжкой, 15-100м, цвет серый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Кол-во в бухте L_м: д.16=100 / д.20=100 / д.25=50 / д.32=25 / д.40=20 / д.50=15; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 350 H на 5 см (легкая серия)*; свыше 750 Н на 5 см (тяжелая серия)*; свыше 1250 Н на 5см (сверхтяжелая серия)*; DKC_Разрывная прочность: не менее 100 Н; DKC_Серия труб: Тяжелая; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Температура монтажа: от –5 до +60 °С; DKC_Температура эксплуатации: от –25 до +60 °С (при отсутствии механических воздействий); DKC_Ударная прочность при –25 °С: не менее 0,5 Дж – легкая серия; не менее 1 Дж – тяжелая и сверхтяжелая серии; Тип трубопровода: 91516
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПВХ гибкая гофр._DKC_д.16-50мм тяжёлая с протяжкой 15-100м цвет серый; Комментарии к типоразмеру: Гофрированная труба из ПВХ (серия 9)
Name (Короб без соединительных деталей:КНС_Труба ПВХ гибкая гофр._DKC_д.16-50мм тяжёлая с протяжкой 15-100м цвет серый:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
695118 | 16 | 11.3 | 1994.37 | 16 ммø | 8 | -8 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
695126 | 16 | 11.3 | 614.371 | 16 ммø | 8 | -8 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
695157 | 20 | 14.7 | 1993.54 | 20 ммø | 10 | -10 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
695163 | 20 | 14.7 | 613.543 | 20 ммø | 10 | -10
695191 | 25 | 18.9 | 1992.51 | 25 ммø | 12.5 | -12.5
695197 | 25 | 18.9 | 612.507 | 25 ммø | 12.5 | -12.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
695228 | 32 | 24.6 | 1991.06 | 32 ммø | 16 | -16
695234 | 32 | 24.6 | 611.057 | 32 ммø | 16 | -16 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
695265 | 40 | 31.5 | 1989.4 | 40 ммø | 20 | -20 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
695271 | 40 | 31.5 | 609.401 | 40 ммø | 20 | -20
695302 | 50 | 40.1 | 1987.33 | 50 ммø | 25 | -25
695308 | 50 | 40.1 | 607.33 | 50 ммø | 25 | -25
