Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:16:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:16:47 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{971527D9-D846-431A-A046-665959D2A826}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:16:45 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:16:46 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:16:46 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (7)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.16мм
300 | Труба ПНД гибкая гофр. д.16-50мм, лёгкая с протяжкой, 15-100м, цвет оранжевый/черный
300 | д.20мм
300 | д.25мм | Идентификация - Вариант конструкции: Главная модель
300 | д.32мм | Идентификация - Вариант конструкции: Главная модель
300 | д.40мм
300 | д.50мм | Идентификация - Вариант конструкции: Главная модель

# IfcDistributionPort (48)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_696443
2 x OutPort_696459
InPort_696451
InPort_696479
2 x OutPort_696493
InPort_696485
InPort_696513
2 x OutPort_696527
InPort_696519
InPort_696548
2 x OutPort_696562
InPort_696554
InPort_696583
2 x OutPort_696605
InPort_696589
InPort_696625
2 x OutPort_696645
InPort_696631
InPort_696874
2 x OutPort_696888
InPort_696880
InPort_696908
2 x OutPort_696922
InPort_696914
InPort_696942
2 x OutPort_696962
InPort_696948
InPort_696982
2 x OutPort_697002
InPort_696988
InPort_697022
2 x OutPort_697036
InPort_697028
InPort_697057
2 x OutPort_697071
InPort_697063

# IfcFlowFitting: Неспецифицируемый_оранжевый (6)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Оранжевый
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Оранжевый; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_оранжевый; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_оранжевый
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый
Размеры - Длина короба: 1 mm; Радиус загиба: 5 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_оранжевый:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
696459 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
696493 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø | Идентификация - Вариант конструкции: Главная модель
696527 | 15.675 | 25 | 12.5 | 0.00000702465 | 7.4928 | 25 ммøx25 ммø
696562 | 19.175 | 32 | 16 | 0.0000137199 | 8.94255 | 32 ммøx32 ммø
696605 | 23.175 | 40 | 20 | 0.000025385 | 10.5994 | 40 ммøx40 ммø | Идентификация - Вариант конструкции: Главная модель
696645 | 28.175 | 50 | 25 | 0.0000473744 | 12.6705 | 50 ммøx50 ммø

# IfcFlowFitting: Неспецифицируемый_черный (6)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Черный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Черный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_черный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_черный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Размеры - Угол: 45 deg; Длина короба: 1 mm; Радиус загиба: 5 mm
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_черный:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
696888 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
696922 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
696962 | 15.675 | 25 | 12.5 | 0.00000702465 | 7.4928 | 25 ммøx25 ммø
697002 | 19.175 | 32 | 16 | 0.0000137199 | 8.94255 | 32 ммøx32 ммø | Идентификация - Вариант конструкции: Главная модель
697036 | 23.175 | 40 | 20 | 0.000025385 | 10.5994 | 40 ммøx40 ммø | Идентификация - Вариант конструкции: Главная модель
697071 | 28.175 | 50 | 25 | 0.0000473744 | 12.6705 | 50 ммøx50 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет оранжевый (12)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет оранжевый; Семейство: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет оранжевый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет оранжевый; Тип: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет оранжевый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД д.16-50мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет оранжевый
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Оранжевый; ADSK_Наименование: Труба ПНД гибкая гофр. д.16-50мм, лёгкая с протяжкой, 15-100м, цвет оранжевый; ADSK_Наименование краткое: Труба ПНД гибкая гофр. д.16-50мм, лёгкая с протяжкой, 15-100м, цвет оранжевый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Кол-во в бухте L_м: д.16=100 / д.20=100 / д.25=50 / д.32=25 / д.40=20 / д.50=15; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; свыше 320 Н на 5 см (тяжелая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Серия труб: Легкая; DKC_Температура монтажа: от –40 до + 90 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Ударная прочность при –25 °С: при -40 °С не менее 2 Дж – легкая серия; не менее 6 Дж – тяжелая серия; Тип трубопровода: 71916
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет оранжевый; Комментарии к типоразмеру: Гофрированная труба из ПНД (серия 7)
Name (Короб без соединительных деталей:КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет оранжевый:...) | Внешний диаметр (mm) | Внутренний диаметр (mm) | Диаметр (Размер по каталогу) (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
696443 | 15.7 | 11.3 | 16 | 1994.37 | 16 ммø | 7.85 | -7.85 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
696451 | 15.7 | 11.3 | 16 | 614.371 | 16 ммø | 7.85 | -7.85 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
696479 | 19.5 | 14.5 | 20 | 1993.54 | 20 ммø | 9.75 | -9.75
696485 | 19.5 | 14.5 | 20 | 613.543 | 20 ммø | 9.75 | -9.75 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
696513 | 25 | 19 | 25 | 1992.51 | 25 ммø | 12.5 | -12.5
696519 | 25 | 19 | 25 | 612.507 | 25 ммø | 12.5 | -12.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
696548 | 31.1 | 24.3 | 32 | 1991.06 | 32 ммø | 15.55 | -15.55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
696554 | 31.1 | 24.3 | 32 | 611.057 | 32 ммø | 15.55 | -15.55
696583 | 38.7 | 30.7 | 40 | 1989.4 | 40 ммø | 19.35 | -19.35 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
696589 | 38.7 | 30.7 | 40 | 609.401 | 40 ммø | 19.35 | -19.35
696625 | 48.5 | 38.9 | 50 | 1987.33 | 50 ммø | 24.25 | -24.25
696631 | 48.5 | 38.9 | 50 | 607.33 | 50 ммø | 24.25 | -24.25

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет черный (12)
In: Этаж 01
Электросети - Стандартное: Стандартные типы коробов: ПНД д.16-50мм; sets with these values: 2
Соединительные детали - Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет черный; Семейство: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет черный; Тип: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет черный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет черный
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет черный; Комментарии к типоразмеру: Гофрированная труба из ПНД (серия 7)
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Наименование: Труба ПНД гибкая гофр. д.16-50мм, лёгкая с протяжкой, 15-100м, цвет черный; ADSK_Наименование краткое: Труба ПНД гибкая гофр. д.16-50мм, лёгкая с протяжкой, 15-100м, цвет черный; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Кол-во в бухте L_м: д.16=100 / д.20=100 / д.25=50 / д.32=25 / д.40=20 / д.50=15; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; свыше 320 Н на 5 см (тяжелая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Серия труб: Легкая; DKC_Температура монтажа: от –40 до + 90 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Ударная прочность при –25 °С: при -40 °С не менее 2 Дж – легкая серия; не менее 6 Дж – тяжелая серия; Тип трубопровода: 71716
Name (Короб без соединительных деталей:КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм лёгкая с протяжкой 15-100м цвет черный:...) | Внешний диаметр (mm) | Внутренний диаметр (mm) | Диаметр (Размер по каталогу) (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
696874 | 15.7 | 11.3 | 16 | 1994.37 | 16 ммø | 7.85 | -7.85
696880 | 15.7 | 11.3 | 16 | 614.371 | 16 ммø | 7.85 | -7.85 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
696908 | 19.5 | 14.5 | 20 | 1993.54 | 20 ммø | 9.75 | -9.75
696914 | 19.5 | 14.5 | 20 | 613.543 | 20 ммø | 9.75 | -9.75
696942 | 25 | 19 | 25 | 1992.51 | 25 ммø | 12.5 | -12.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
696948 | 25 | 19 | 25 | 612.507 | 25 ммø | 12.5 | -12.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
696982 | 31.1 | 24.3 | 32 | 1991.06 | 32 ммø | 15.55 | -15.55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
696988 | 31.1 | 24.3 | 32 | 611.057 | 32 ммø | 15.55 | -15.55
697022 | 38.7 | 30.7 | 40 | 1989.4 | 40 ммø | 19.35 | -19.35
697028 | 38.7 | 30.7 | 40 | 609.401 | 40 ммø | 19.35 | -19.35 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
697057 | 48.5 | 38.9 | 50 | 1987.33 | 50 ммø | 24.25 | -24.25
697063 | 48.5 | 38.9 | 50 | 607.33 | 50 ммø | 24.25 | -24.25
