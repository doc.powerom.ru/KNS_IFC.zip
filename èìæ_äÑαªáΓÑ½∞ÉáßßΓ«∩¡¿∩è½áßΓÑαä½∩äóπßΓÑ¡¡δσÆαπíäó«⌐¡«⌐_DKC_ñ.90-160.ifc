Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T19:59:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 19:59:48 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{EA0F0354-C555-4634-851B-6C2D082AF22F}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 19:59:48 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 19:59:48 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 19:59:48 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (6)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.90мм | Идентификация - Вариант конструкции: Главная модель
300 | д.110мм
300 | д.125мм | Идентификация - Вариант конструкции: Главная модель
300 | д.140мм
300 | д.160мм
300 | Двойной | Идентификация - Вариант конструкции: Главная модель

# IfcFlowFitting: д.110мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160:д.110мм:562289
In: Этаж 01
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025112; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.110мм, двойной; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.110мм, двойной; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025112/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.110мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160
Type - Размеры - H: 142 mm; L1: 284 mm; L1half: 142 mm; L3: 142 mm; R: 56 mm; S: 25 mm
Type - Текст - ADSK_Масса: 0.129
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.110мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.110мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.110мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.110мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.110мм
Размеры - Объем: 0.000515622 m3; Площадь: 0.034473 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.125мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160:д.125мм:562291
In: Этаж 01
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025122; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.125мм, двойной; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.125мм, двойной; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025122/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.125мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160
Type - Размеры - H: 140 mm; L1: 314 mm; L1half: 157 mm; L3: 164 mm; R: 63 mm; S: 25 mm
Type - Текст - ADSK_Масса: 0.347
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.125мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.125мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.125мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.125мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.125мм
Размеры - Объем: 0.000475581 m3; Площадь: 0.0339713 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.140мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160:д.140мм:562293
In: Этаж 01
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025142; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.140мм, двойной; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.140мм, двойной; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025142/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.140мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160
Type - Размеры - H: 150 mm; L1: 332 mm; L1half: 166 mm; L3: 166 mm; R: 71 mm; S: 40 mm
Type - Текст - ADSK_Масса: 0.318
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.140мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.140мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.140мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.140мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.140мм
Размеры - Объем: 0.000725119 m3; Площадь: 0.0438949 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.160мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160:д.160мм:562295
In: Этаж 01
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025162; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.160мм, двойной; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.160мм, двойной; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025162/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.160мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160
Type - Размеры - H: 175 mm; L1: 390 mm; L1half: 195 mm; L3: 200 mm; R: 82 mm; S: 30 mm
Type - Текст - ADSK_Масса: 0.251
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.160мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.160мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.160мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.160мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.160мм
Размеры - Объем: 0.000780116 m3; Площадь: 0.048574 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.90мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160:д.90мм:562287
In: Этаж 01
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025902; ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.90мм, двойной; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.90мм, двойной; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025902/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.90мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160
Type - Размеры - H: 100 mm; L1: 238 mm; L1half: 119 mm; L3: 124 mm; R: 46 mm; S: 25 mm
Type - Текст - ADSK_Масса: 0.09
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.90мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.90мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.90мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.90мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубДвойной_DKC_д.90-160: д.90мм
Размеры - Объем: 0.000262635 m3; Площадь: 0.0215822 m2
Стадии - Стадия возведения: Стадия 1
