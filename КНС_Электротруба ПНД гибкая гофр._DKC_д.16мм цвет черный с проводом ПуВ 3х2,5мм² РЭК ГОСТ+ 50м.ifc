Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:13:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:13:13 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{3ACE7579-3570-4A40-B884-1EFD3CD063FB}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:13:13 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:13:13 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:13:13 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300 (2)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.16мм 3x2,5мм² 50м
300 | Электротруба ПНД гибкая гофр. д.16мм, цвет черный/оранжевый, с проводом ПуВ 3х2,5мм² РЭК ГОСТ+, 50м

# IfcDistributionPort (8)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_693462
2 x OutPort_693476
InPort_693468
InPort_693496
2 x OutPort_693510
InPort_693502

# IfcFlowFitting: Неспецифицируемый_оранжевый, КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_оранжевый:693510
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Оранжевый
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Оранжевый; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_оранжевый; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_оранжевый
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый
Размеры - Угол: 45 deg; Длина короба: 1 mm; Метка радиуса загиба: 11.175 mm; Наружный диаметр фитинга: 16 mm; Наружный радиус фитинга: 8 mm; Номинальный диаметр: 16 mm; Номинальный радиус: 8 mm; Объем: 0.00000216672 m3; От центра до конца: 5.62884 mm; Радиус загиба: 5 mm; Размер: 16 ммøx16 ммø
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: Неспецифицируемый_черный, КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_черный:693476
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Черный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Черный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_черный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_черный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Размеры - Длина короба: 1 mm; Метка радиуса загиба: 11.175 mm; Наружный диаметр фитинга: 16 mm; Наружный радиус фитинга: 8 mm; Номинальный диаметр: 16 mm; Номинальный радиус: 8 mm; Объем: 0.00000216672 m3; От центра до конца: 5.62884 mm; Радиус загиба: 5 mm; Размер: 16 ммøx16 ммø; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Оранжевый; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с проводом ПуВ 3х2,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с проводом ПуВ 3х2,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ПуВ 3х2,5мм²; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71638
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
693496 | 1994.37
693502 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с проводом ПуВ 3х2,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с проводом ПуВ 3х2,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ПуВ 3х2,5мм²; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71631
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с проводом ПуВ 3х2,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
693462 | 1994.37
693468 | 614.371 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
