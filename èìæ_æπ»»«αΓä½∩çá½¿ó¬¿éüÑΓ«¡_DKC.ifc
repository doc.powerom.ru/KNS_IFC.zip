Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:08:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:08:07 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B2FEE49C-129C-49BE-B2AD-E94120EB8AE5}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:08:07 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:08:07 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:08:07 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes; Имя типа: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300 (2)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | 71х71х17 | Идентификация - Вариант конструкции: Главная модель
300 | Суппорт для заливки в бетон

# IfcFlowFitting: 71х71х17мм, КНС_СуппортДляЗаливкиВБетон_DKC:71х71х17мм:757025
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Красный
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59388; ADSK_Материал: DKC_Пластик_Полипропилен_Красный; ADSK_Наименование: Суппорт для заливки в бетон, 71х71х17мм; DKC_Температура эксплуатации: от –25 до +100 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59388/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 71х71х17мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление коробок установочных для заливки в бетон на встречную опалубку при монолитном бетоностроении
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_СуппортДляЗаливкиВБетон_DKC
Type - Размеры - DN: 20 mm
Type - Текст - ADSK_Масса: 0.013
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 71х71х17мм
Графика - Использовать масштаб аннотаций: no
Данные - ADSK_Наименование краткое: Суппорт для заливки в бетон, 71х71х17мм
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_СуппортДляЗаливкиВБетон_DKC: 71х71х17мм; Семейство: КНС_СуппортДляЗаливкиВБетон_DKC: 71х71х17мм; Семейство и типоразмер: КНС_СуппортДляЗаливкиВБетон_DKC: 71х71х17мм; Тип: КНС_СуппортДляЗаливкиВБетон_DKC: 71х71х17мм
Размеры - Объем: 0.000020321 m3; Площадь: 0.00897717 m2; Размер: 20 ммø
Стадии - Стадия возведения: Стадия 1
