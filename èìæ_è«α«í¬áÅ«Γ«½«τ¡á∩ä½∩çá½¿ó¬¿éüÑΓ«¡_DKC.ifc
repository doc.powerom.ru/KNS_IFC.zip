Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:07:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:07:52 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{47947BF2-2CD5-40D8-874E-50E049575ADD}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:07:52 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:07:52 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:07:52 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300 (2)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | 72х72х65
300 | Универсальная потолочная коробка для заливки в бетон

# IfcFlowFitting: 55мм, КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC:55мм:779780
In: Этаж 01
Type - Material: DKC_Сталь
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59055; ADSK_Материал: DKC_Сталь; ADSK_Наименование: Крюк изолированный для коробки потолочной, 55мм
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59055/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 55мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: подвес люстры к залитой в бетон коробке потолочной
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC
Type - Размеры - ADSK_Размер_Длина: 55 mm
Type - Текст - ADSK_Масса: 0.03
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 55мм
Данные - ADSK_Наименование краткое: Крюк изолированный для коробки потолочной, 55мм
Зависимости - Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 58.484 mm
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 55мм; Семейство: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 55мм; Семейство и типоразмер: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 55мм; Тип: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 55мм
Размеры - Объем: 0.00000436035 m3; Площадь: 0.0014817 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 72х72х65мм, КНС_КоробкаПотолочнаяДляЗаливкиВБетон_DKC:72х72х65мм:755830
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Синий, DKC_Пластик_Полипропилен_Красный
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59391; ADSK_Материал: DKC_Пластик_Полипропилен_Красный; ADSK_Наименование: Коробка потолочная для заливки в бетон, д.72х65мм; ADSK_Примечание: фланцевая крышка – 1 шт.; крышка конусная с встроенной гайкой М6 – 1 шт.; DKC_Температура эксплуатации: от –25 до +100 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59391/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 72х72х65мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: формирование потолочной распределительной коробки с крюком для подвеса люстры при монолитном бетоностроении
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаПотолочнаяДляЗаливкиВБетон_DKC
Type - Размеры - DN: 20 mm; DN2: 25 mm
Type - Текст - ADSK_Масса: 0.037
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 72х72х65мм
Видимость - Видимость крюка: yes; Тип крюка: КНС_КрюкИзолированныйДляКоробкиПотолочной_DKC: 55мм
Графика - Использовать масштаб аннотаций: no
Данные - ADSK_Наименование краткое: Коробка потолочная для заливки в бетон, д.72х65мм
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_КоробкаПотолочнаяДляЗаливкиВБетон_DKC: 72х72х65мм; Семейство: КНС_КоробкаПотолочнаяДляЗаливкиВБетон_DKC: 72х72х65мм; Семейство и типоразмер: КНС_КоробкаПотолочнаяДляЗаливкиВБетон_DKC: 72х72х65мм; Тип: КНС_КоробкаПотолочнаяДляЗаливкиВБетон_DKC: 72х72х65мм
Размеры - Объем: 0.000130303 m3; Площадь: 0.0123196 m2; Размер: 25 ммøx25 ммøx20 ммøx20 ммø
Стадии - Стадия возведения: Стадия 1
