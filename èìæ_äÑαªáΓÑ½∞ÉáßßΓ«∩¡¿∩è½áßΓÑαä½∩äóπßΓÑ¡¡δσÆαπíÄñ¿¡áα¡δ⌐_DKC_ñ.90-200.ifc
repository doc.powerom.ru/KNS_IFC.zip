Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T19:59:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 19:59:31 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{735951BC-2049-4EFD-A697-A7A6EA8E1AF1}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 19:59:30 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 19:59:30 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 19:59:30 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (6)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.90мм | Идентификация - Вариант конструкции: Главная модель
300 | д.110мм
300 | д.125мм
300 | д.160мм
300 | д.200мм
300 | Одинарный | Идентификация - Вариант конструкции: Главная модель

# IfcFlowFitting: д.110мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200:д.110мм:558340
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025111; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.110мм, одинарный; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.110мм, одинарный; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025111/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.110мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200
Type - Размеры - H: 142 mm; L1: 140 mm; R: 56 mm; S: 25 mm
Type - Текст - ADSK_Масса: 0.06
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.110мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.110мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.110мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.110мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.110мм
Размеры - Объем: 0.000250711 m3
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.125мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200:д.125мм:558342
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025121; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.125мм, одинарный; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.125мм, одинарный; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025121/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.125мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200
Type - Размеры - H: 140 mm; L1: 150 mm; R: 63 mm; S: 25 mm
Type - Текст - ADSK_Масса: 0.07
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.125мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.125мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.125мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.125мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.125мм
Размеры - Объем: 0.00021329 m3
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.160мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200:д.160мм:558346
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025161; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.160мм, одинарный; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.160мм, одинарный; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025161/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.160мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200
Type - Размеры - H: 175 mm; L1: 190 mm; R: 82 mm; S: 30 mm
Type - Текст - ADSK_Масса: 0.11
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.160мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.160мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.160мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.160мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.160мм
Размеры - Объем: 0.000363808 m3
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.200мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200:д.200мм:558348
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025201; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.200мм, одинарный; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.200мм, одинарный; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025201/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.200мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200
Type - Размеры - H: 240 mm; L1: 230 mm; R: 101 mm; S: 40 mm
Type - Текст - ADSK_Масса: 0.28
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.200мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.200мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.200мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.200мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.200мм
Размеры - Объем: 0.000926165 m3
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: д.90мм, КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200:д.90мм:558338
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025901; ADSK_Материал: DKC_Пластик_Полипропилен; ADSK_Наименование: Держатель расстояния (кластер) для двустенных труб, д.90мм, одинарный; ADSK_Наименование краткое: Держатель расстояния (кластер) для двустенных труб, д.90мм, одинарный; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025901/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: д.90мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: крепление труб, препятствие смещению, сохранение расстояния между гибкими, жесткими, дренажными гофрированными двустенными трубами одного диаметра.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200
Type - Размеры - H: 100 mm; L1: 114 mm; R: 46 mm; S: 25 mm
Type - Текст - ADSK_Масса: 0.04
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: д.90мм
Графика - Использовать масштаб аннотаций: no
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.90мм; Семейство: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.90мм; Семейство и типоразмер: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.90мм; Тип: КНС_ДержательРасстоянияКластерДляДвустенныхТрубОдинарный_DKC_д.90-200: д.90мм
Размеры - Объем: 0.000118818 m3
Стадии - Стадия возведения: Стадия 1
