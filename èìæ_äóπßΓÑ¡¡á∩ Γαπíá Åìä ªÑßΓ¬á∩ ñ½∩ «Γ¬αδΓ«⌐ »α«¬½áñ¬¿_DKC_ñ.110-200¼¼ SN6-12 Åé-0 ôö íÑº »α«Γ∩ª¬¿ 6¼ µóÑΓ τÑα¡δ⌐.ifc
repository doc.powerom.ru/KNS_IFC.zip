Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T16:11:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 16:11:49 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{44C6F939-0C3A-467C-8694-923D09C9F21D}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 16:11:48 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 16:11:48 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 16:11:48 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (5)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.110мм
300 | д.125мм | Главная модель
300 | д.160мм | Главная модель
300 | д.200мм | Главная модель
300 | Двустенная труба ПНД жесткая для открытой прокладки, д.110-200мм, SN6-12, ПВ-0, УФ, без протяжки, 6м, цвет черный

# IfcDistributionPort (16)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_636972
2 x OutPort_686299
InPort_636973
2 x OutPort_686340
InPort_636974
2 x OutPort_686392
InPort_636975
2 x OutPort_686426
InPort_686278
InPort_686319
InPort_686371
InPort_686413

# IfcFlowFitting: Неспецифицируемый_черный (4)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Черный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Черный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_черный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_черный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Размеры - Длина короба: 1 mm; Радиус загиба: 10 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_черный:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
686299 | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø
686340 | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø | Идентификация - Вариант конструкции: Главная модель
686392 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø | Идентификация - Вариант конструкции: Главная модель
686426 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для открытой прокладки_DKC_д.110-200мм SN6-12 ПВ-0 УФ без протяжки 6м цвет черный (8)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для открытой прокладки_DKC_д.110-200мм SN6-12 ПВ-0 УФ без протяжки 6м цвет черный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для открытой прокладки_DKC_д.110-200мм SN6-12 ПВ-0 УФ без протяжки 6м цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для открытой прокладки_DKC_д.110-200мм SN6-12 ПВ-0 УФ без протяжки 6м цвет черный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД жесткая для открытой прокладки_DKC_д.110-200мм SN6-12 ПВ-0 УФ без протяжки 6м цвет черный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД жесткая для открытой прокладки
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД жесткая для открытой прокладки_DKC_д.110-200мм SN6-12 ПВ-0 УФ без протяжки 6м цвет черный
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-047-47022248-2015; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Наименование: Двустенная труба ПНД жесткая для открытой прокладки, д.110-200мм, SN6-12, ПВ-0, УФ, без протяжки, 6м, цвет черный; ADSK_Наименование краткое: Двустенная труба ПНД жесткая для открытой прокладки, д.110-200мм, SN6-12, ПВ-0, УФ, без протяжки, 6м, цвет черный; DKC_Длина отрезков L_м: 6; DKC_Исполнение: Исполнение 1 – стандартное исполнение отрезков трубы по 6 м, соединительная муфта одета на торец отрезка трубы; DKC_Климатическое исполнение: У1 по ГОСТ 15150-69; DKC_Кольцевая жесткость_кПа: д.110 SN12=12 / д.125 SN10=10 / д.160 SN6=6 / д.200 SN6=6; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Стойкость к ультрафиолету: В соответствии с ГОСТ Р 20.57.406 метод 211-1; DKC_Температура монтажа: от –25 до + 90 °С; DKC_Температура эксплуатации: от –55 до + 90 °С; DKC_Условия монтажа: Для прокладки кабельных линий в открытых кабельных сооружениях и наружных электроустановок: мосты; путепроводы, эстакады, галереи, места выходов из земли и вводы в здание; Тип трубопровода: 170911
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/61/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД жесткая для открытой прокладки_DKC_д.110-200мм SN6-12 ПВ-0 УФ без протяжки 6м цвет черный; Комментарии к типоразмеру: Жесткие двустенные трубы для открытой прокладки
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД жесткая для открытой прокладки_DKC_д.110-200мм SN6-12 ПВ-0 УФ без протяжки 6м цвет черный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
636972 | 110 | 92 | 1949.81 | 110 ммø | 55 | -55
636973 | 125 | 107 | 1943.59 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
636974 | 160 | 137 | 1929.1 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
636975 | 200 | 172 | 1912.53 | 200 ммø | 100 | -100
686278 | 110 | 92 | 574.903 | 110 ммø | 55 | -55
686319 | 125 | 107 | 571.797 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686371 | 160 | 137 | 564.548 | 160 ммø | 80 | -80 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
686413 | 200 | 172 | 456.264 | 200 ммø | 100 | -100
