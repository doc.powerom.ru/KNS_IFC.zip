Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T19:58:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 19:58:45 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{F8545B8E-F7A2-41B7-8E0E-CC2274D2876D}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 19:58:44 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 19:58:44 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 19:58:44 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (9)
In: Этаж 01
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Прочее - Категория: Обобщенные модели; Имя семейства: Текст модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300
Идентификация - Имя типа: 300; Подкатегория: Обобщенные модели
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Name (Текст модели:...) | Текст
300 | д.50мм | Идентификация - Вариант конструкции: Главная модель
300 | д.63мм
300 | д.75мм | Идентификация - Вариант конструкции: Главная модель
300 | д.90мм
300 | д.110мм | Идентификация - Вариант конструкции: Главная модель
300 | д.125мм
300 | д.140мм | Идентификация - Вариант конструкции: Главная модель
300 | д.160мм
300 | д.200мм

# IfcFlowFitting: Заглушка (9)
In: Этаж 01
Type - Material: DKC_Пластик_Полиэтилен
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Пластик_Полиэтилен; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Заглушка; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: защита гибких, жестких, дренажных гофрированных двустенных труб со свободных концов от попадания влаги и грязи в процессе монтажа, эксплуатации и хранения
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ЗаглушкаДляДвустенныхТруб_DKC_д.50-200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Заглушка
Видимость - DKC_Уплотнительное резиновое кольцо: yes
Графика - Использовать масштаб аннотаций: no
Данные - DKC_Степень защиты: IP 55
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_ЗаглушкаДляДвустенныхТруб_DKC_д.50-200: Заглушка; Семейство: КНС_ЗаглушкаДляДвустенныхТруб_DKC_д.50-200: Заглушка; Семейство и типоразмер: КНС_ЗаглушкаДляДвустенныхТруб_DKC_д.50-200: Заглушка; Тип: КНС_ЗаглушкаДляДвустенныхТруб_DKC_д.50-200: Заглушка
Стадии - Стадия возведения: Стадия 1
Name (КНС_ЗаглушкаДляДвустенныхТруб_DKC_д.50-200:Заглушка:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | Вариант конструкции | A (mm) | D (mm) | DN (mm) | H (mm) | L (mm) | Объем (m3) | Размер | ADSK_Масса
544992 | 50950 | Заглушка для двустенных труб наружная полиэтилен 50мм | Главная модель | 51 | 55 | 50 | 10 | 11 | 0.00000316452 | 50 ммø | 0.005
545003 | 023063 | Заглушка для двустенных труб наружная полиэтилен 63мм | Главная модель | 65 | 68 | 63 | 27 | 29 | 0.0000124342 | 63 ммø | 0.013
545015 | 023075 | Заглушка для двустенных труб наружная полиэтилен 75мм | Главная модель | 77 | 79 | 75 | 27 | 29 | 0.000015994 | 75 ммø | 0.02
545027 | 023090 | Заглушка для двустенных труб наружная полиэтилен 90мм | Главная модель | 92 | 98 | 90 | 33 | 35 | 0.0000236114 | 90 ммø | 0.024
545039 | 023110 | Заглушка для двустенных труб наружная полиэтилен 110мм | Главная модель | 112 | 119 | 110 | 32 | 34 | 0.0000321226 | 110 ммø | 0.02
545051 | 023125 | Заглушка для двустенных труб наружная полиэтилен 125мм |  | 127 | 132 | 125 | 32 | 34 | 0.0000390546 | 125 ммø | 0.045
545063 | 023140 | Заглушка для двустенных труб наружная полиэтилен 140мм |  | 143 | 146 | 140 | 32 | 34 | 0.0000541284 | 140 ммø | 0.055
545075 | 023160 | Заглушка для двустенных труб наружная полиэтилен 160мм |  | 162 | 168 | 160 | 32 | 34 | 0.0000589547 | 160 ммø | 0.09
545086 | 023200 | Заглушка для двустенных труб наружная полиэтилен 200мм |  | 204 | 208 | 200 | 47 | 50 | 0.000158988 | 200 ммø | 0.084

# IfcFlowFitting: Кольцо резиновое уплотнительное (9)
In: Этаж 01
Type - Material: DKC_Резина
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Резина; DKC_Степень защиты: IP 55 с аксессуарами; DKC_Температура эксплуатации: от –25 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Кольцо резиновое уплотнительное; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: герметизация мест соединения гибких, жестких, дренажных гофрированных двустенных труб с соединительными муфтами, заглушками, разветвителями, переходниками
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Кольцо резиновое уплотнительное
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no
Прочее - Код типа: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Семейство: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Семейство и типоразмер: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное; Тип: КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200: Кольцо резиновое уплотнительное
Стадии - Стадия возведения: Стадия 1
Name (КНС_КольцоРезиновоеУплотнительноеДляДвустеннойТрубы_DKC_д.50-200:Кольцо резиновое уплотнительное:...) | ADSK_Код изделия | ADSK_Наименование = ADSK_Наименование краткое | Вариант конструкции | A (mm) | DN (mm) | Dвнеш (mm) | Dвнут (mm) | Объем (m3) | ADSK_Масса
549389 | 016050 | Кольцо резиновое уплотнительное для двустенной трубы 50мм | Главная модель | 2 | 50 | 49.5 | 39 | 0.00000145959 | 0.002
549393 | 016063 | Кольцо резиновое уплотнительное для двустенной трубы 63мм |  | 2 | 63 | 62.5 | 50 | 0.00000220883 | 0.004
549397 | 016075 | Кольцо резиновое уплотнительное для двустенной трубы 75мм | Главная модель | 2 | 75 | 74.6 | 60.4 | 0.00000301107 | 0.007
549401 | 016090 | Кольцо резиновое уплотнительное для двустенной трубы 90мм |  | 2.5 | 90 | 93 | 70 | 0.00000736079 | 0.009
549405 | 016110 | Кольцо резиновое уплотнительное для двустенной трубы 110мм | Главная модель | 4.2 | 110 | 110.7 | 87 | 0.0000154552 | 0.015
549409 | 016125 | Кольцо резиновое уплотнительное для двустенной трубы 125мм |  | 3 | 125 | 128.7 | 100 | 0.0000154646 | 0.016
549413 | 016140 | Кольцо резиновое уплотнительное для двустенной трубы 140мм | Главная модель | 4 | 140 | 144 | 117 | 0.0000221378 | 0.019
549417 | 016160 | Кольцо резиновое уплотнительное для двустенной трубы 160мм |  | 4 | 160 | 164.5 | 131 | 0.0000310979 | 0.031
549421 | 016200 | Кольцо резиновое уплотнительное для двустенной трубы 200мм | Главная модель | 5 | 200 | 204.5 | 166 | 0.0000560129 | 0.06
