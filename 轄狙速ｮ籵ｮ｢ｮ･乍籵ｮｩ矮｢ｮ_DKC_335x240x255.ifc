Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:04:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:04:08 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{F4EF2E52-9168-48A9-A460-A205F47D2C80}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:04:08 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:04:08 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:04:08 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300 (2)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | 335х240х255 мм | Идентификация - Вариант конструкции: Главная модель
300 | 335х240х255 мм (без дна)

# IfcFlowFitting: Смотровое устройство, КНС_СмотровоеУстройство_DKC_335x240x255:Смотровое устройство:636871
In: Этаж 01
Type - Material: DKC_Пластик_Высокопрочный полипропилен
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025002; ADSK_Материал: DKC_Пластик_Высокопрочный полипропилен; ADSK_Наименование: Смотровой переходной колодец с крышкой для двустенных труб, 335х240х255мм; DKC_Степень защиты: IP 65; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025002/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Смотровое устройство; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: устройство наружного освещения и сигнализации, подвод двустенных труб к мачтам освещения
Type - Прочее - Категория: Соединительные детали коробов; Дно: yes; Имя семейства: КНС_СмотровоеУстройство_DKC_335x240x255
Type - Размеры - ADSK_Размер_Высота: 255 mm; ADSK_Размер_Длина: 335 mm; ADSK_Размер_Ширина: 240 mm
Type - Текст - ADSK_Масса: 3.201
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Смотровое устройство
Видимость - Видимость крышки: yes
Графика - Использовать масштаб аннотаций: no
Данные - ADSK_Наименование краткое: Смотровой переходной колодец с крышкой для двустенных труб, 335х240х255мм
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_СмотровоеУстройство_DKC_335x240x255: Смотровое устройство; Семейство: КНС_СмотровоеУстройство_DKC_335x240x255: Смотровое устройство; Семейство и типоразмер: КНС_СмотровоеУстройство_DKC_335x240x255: Смотровое устройство; Тип: КНС_СмотровоеУстройство_DKC_335x240x255: Смотровое устройство
Размеры - DN1: 50 mm; DN2: 50 mm; DN3: 50 mm; DN4: 50 mm; Объем: 0.00366185 m3; Площадь: 0.466112 m2; Размер: 50 ммøx50 ммøx50 ммøx50 ммø
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: Смотровое устройство (без дна), КНС_СмотровоеУстройство_DKC_335x240x255:Смотровое устройство (без дна):636895
In: Этаж 01
Type - Material: DKC_Пластик_Высокопрочный полипропилен
Type - Данные - ADSK_Материал: DKC_Пластик_Высокопрочный полипропилен; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 025003; ADSK_Наименование: Смотровой переходной колодец без дна для двустенных труб, 335х240х255мм; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/025003/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Смотровое устройство (без дна); Номер OmniClass: 23.80.30.17.11; Описание: Назначение: устройство наружного освещения и сигнализации, подвод двустенных труб к мачтам освещения
Type - Прочее - Категория: Соединительные детали коробов; Дно: no; Имя семейства: КНС_СмотровоеУстройство_DKC_335x240x255
Type - Размеры - ADSK_Размер_Высота: 255 mm; ADSK_Размер_Длина: 335 mm; ADSK_Размер_Ширина: 240 mm
Type - Текст - ADSK_Масса: 2.9
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Смотровое устройство (без дна)
Видимость - Видимость крышки: yes
Графика - Использовать масштаб аннотаций: no
Данные - ADSK_Наименование краткое: Смотровой переходной колодец без дна для двустенных труб, 335х240х255мм
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_СмотровоеУстройство_DKC_335x240x255: Смотровое устройство (без дна); Семейство: КНС_СмотровоеУстройство_DKC_335x240x255: Смотровое устройство (без дна); Семейство и типоразмер: КНС_СмотровоеУстройство_DKC_335x240x255: Смотровое устройство (без дна); Тип: КНС_СмотровоеУстройство_DKC_335x240x255: Смотровое устройство (без дна)
Размеры - DN1: 50 mm; DN2: 50 mm; DN3: 50 mm; DN4: 50 mm; Объем: 0.0032881 m3; Площадь: 0.466112 m2; Размер: 50 ммøx50 ммøx50 ммøx50 ммø
Стадии - Стадия возведения: Стадия 1
