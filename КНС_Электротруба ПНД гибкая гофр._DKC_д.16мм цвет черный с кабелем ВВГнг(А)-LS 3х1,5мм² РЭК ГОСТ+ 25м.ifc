Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:12:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:12:28 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{CAA98975-5869-4082-B343-EF678468D7D0}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:12:26 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:12:26 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:12:26 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (7)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.16мм 3x1,5мм² 25м | Идентификация - Вариант конструкции: Главная модель
300 | Электротруба ПНД гибкая гофр. д.16/20мм, цвет черный/оранжевый, с кабелем ВВГнг(А)-LS 3х1,5мм²/3х2,5мм² РЭК ГОСТ+, 25/50/100м
300 | д.16мм 3x1,5мм² 50м | Идентификация - Вариант конструкции: Главная модель
300 | д.16мм 3x2,5мм² 25м
300 | д.16мм 3x1,5мм² 100м
300 | д.20мм 3x2,5мм² 100м | Идентификация - Вариант конструкции: Главная модель
300 | д.16мм 3x2,5мм² 50м

# IfcDistributionPort (48)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_692791
2 x OutPort_692809
InPort_692797
InPort_692829
2 x OutPort_692848
InPort_692835
InPort_692868
2 x OutPort_692882
InPort_692874
InPort_692902
2 x OutPort_692916
InPort_692908
InPort_692936
2 x OutPort_692950
InPort_692942
InPort_692981
2 x OutPort_692995
InPort_692987
InPort_693015
2 x OutPort_693029
InPort_693021
InPort_693049
2 x OutPort_693063
InPort_693055
InPort_693089
2 x OutPort_693103
InPort_693095
InPort_693129
2 x OutPort_693143
InPort_693135
InPort_693166
2 x OutPort_693186
InPort_693172
InPort_693206
2 x OutPort_693226
InPort_693212

# IfcFlowFitting: Неспецифицируемый_оранжевый (6)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Оранжевый
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Оранжевый; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_оранжевый; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_оранжевый
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый
Размеры - Угол: 45 deg; Длина короба: 1 mm; Радиус загиба: 5 mm
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_оранжевый:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
692848 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
692916 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
692995 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
693063 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
693143 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
693226 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø

# IfcFlowFitting: Неспецифицируемый_черный (6)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Черный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Черный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_черный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_черный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Размеры - Длина короба: 1 mm; Радиус загиба: 5 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_черный:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
692809 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
692882 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
692950 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø | Идентификация - Вариант конструкции: Главная модель
693029 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø | Идентификация - Вариант конструкции: Главная модель
693103 | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø | Идентификация - Вариант конструкции: Главная модель
693186 | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Оранжевый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 100м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 100м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 100; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х1,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71634
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м:...) | Длина (mm)
692981 | 1994.37
692987 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Оранжевый; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 25м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 25м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 25; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х1,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71632
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м:...) | Длина (mm)
692829 | 1994.37
692835 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Оранжевый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х1,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71633
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
692902 | 1994.37 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
692908 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Оранжевый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 25м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 25м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 25; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х2,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71635
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м:...) | Длина (mm)
693049 | 1994.37 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
693055 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Оранжевый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х2,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71636
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
693129 | 1994.37 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
693135 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 100м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 100м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 100; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х1,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71627
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 100м:...) | Длина (mm)
692936 | 1994.37
692942 | 614.371 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Идентификация - Вариант конструкции: Главная модель; sets with these values: 2; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 25м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 25м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 25; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х1,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71625
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 25м:...) | Длина (mm)
692791 | 1994.37
692797 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х1,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71626
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
692868 | 1994.37 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
692874 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 25м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 25м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 25; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х2,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71628
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 25м:...) | Длина (mm)
693015 | 1994.37
693021 | 614.371

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 15.7 mm; Внутренний диаметр: 11.3 mm; Диаметр (Размер по каталогу): 16 mm; Размер: 16 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 7.85 mm; Нижняя отметка: -7.85 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.16мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 50м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+, 50м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 50; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х2,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71629
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.16мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 50м:...) | Длина (mm)
693089 | 1994.37
693095 | 614.371 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 19.5 mm; Внутренний диаметр: 14.5 mm; Диаметр (Размер по каталогу): 20 mm; Размер: 20 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 9.75 mm; Нижняя отметка: -9.75 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.20мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Оранжевый; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 100м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет оранжевый, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 100м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 100; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х2,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71637
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная; Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет оранжевый с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м:...) | Длина (mm)
693206 | 1993.54
693212 | 613.543 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2

# IfcFlowSegment: Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м (2)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Семейство: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Семейство и типоразмер: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Тип: Короб без соединительных деталей: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - Внешний диаметр: 19.5 mm; Внутренний диаметр: 14.5 mm; Диаметр (Размер по каталогу): 20 mm; Размер: 20 ммø; sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - Верхняя отметка: 9.75 mm; Нижняя отметка: -9.75 mm; sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая гофр. д.20мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м
Данные - ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Наименование: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 100м; ADSK_Наименование краткое: Электротруба ПНД гибкая гофр. д.16мм, цвет черный, с кабелем ВВГнг(А)-LS 3х1,5мм² РЭК ГОСТ+, 100м; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 1342 (легкая серия); 2442 (тяжелая серия); DKC_Кол-во в бухте L_м: 100; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Температура монтажа: от –15 до +65 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Тип кабеля: ВВГнг(А)-LS 3х2,5; DKC_Ударная прочность при –25 °С: при - 40 °С не менее 2 Дж – легкая серия; Тип трубопровода: 71630
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м; Комментарии к типоразмеру: Гофрированная электротруба из ПНД
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Name (Короб без соединительных деталей:КНС_Электротруба ПНД гибкая гофр._DKC_д.20мм цвет черный с кабелем ВВГнг(А)-LS 3х2,5мм² РЭК ГОСТ+ 100м:...) | Длина (mm)
693166 | 1993.54 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
693172 | 613.543
