Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:17:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:17:44 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{3939AC3E-4FE8-4CC6-B782-774B5B313F99}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:17:43 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:17:43 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:17:43 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (7)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.16мм
300 | Труба ПНД гибкая гофр. д.16-50мм, тяжелая без протяжки, 15-100м, цвет оранжевый
300 | д.20мм | Главная модель
300 | д.25мм | Главная модель
300 | д.32мм
300 | д.40мм | Главная модель
300 | д.50мм | Главная модель

# IfcDistributionPort (24)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_697545
2 x OutPort_697559
InPort_697551
InPort_697581
2 x OutPort_697597
InPort_697587
InPort_697618
2 x OutPort_697632
InPort_697624
InPort_697652
2 x OutPort_697666
InPort_697658
InPort_697686
2 x OutPort_697700
InPort_697692
InPort_697720
2 x OutPort_697734
InPort_697726

# IfcFlowFitting: Неспецифицируемый_оранжевый (6)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Оранжевый
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Оранжевый; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_оранжевый; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_оранжевый
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый
Размеры - Длина короба: 1 mm; Радиус загиба: 5 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_оранжевый:...) | Вариант конструкции | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
697559 | Главная модель | 11.175 | 16 | 8 | 0.00000216672 | 5.62884 | 16 ммøx16 ммø
697597 | Главная модель | 13.175 | 20 | 10 | 0.00000387896 | 6.45726 | 20 ммøx20 ммø
697632 |  | 15.675 | 25 | 12.5 | 0.00000702465 | 7.4928 | 25 ммøx25 ммø
697666 | Главная модель | 19.175 | 32 | 16 | 0.0000137199 | 8.94255 | 32 ммøx32 ммø
697700 | Главная модель | 23.175 | 40 | 20 | 0.000025385 | 10.5994 | 40 ммøx40 ммø
697734 | Главная модель | 28.175 | 50 | 25 | 0.0000473744 | 12.6705 | 50 ммøx50 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм тяжелая без протяжки 15-100м цвет оранжевый (12)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм тяжелая без протяжки 15-100м цвет оранжевый; Семейство: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм тяжелая без протяжки 15-100м цвет оранжевый; Семейство и типоразмер: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм тяжелая без протяжки 15-100м цвет оранжевый; Тип: Короб без соединительных деталей: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм тяжелая без протяжки 15-100м цвет оранжевый; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД д.16-50мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм тяжелая без протяжки 15-100м цвет оранжевый
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_оранжевый; Соединение: КНС_МуфтаДляГофрированныхТруб_DKC_д.16-50: Муфта соединительная
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 3491-011-47022248-2003; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Оранжевый; ADSK_Наименование: Труба ПНД гибкая гофр. д.16-50мм, тяжелая без протяжки, 15-100м, цвет оранжевый; ADSK_Наименование краткое: Труба ПНД гибкая гофр. д.16-50мм, тяжелая с протяжкой, 15-100м, цвет оранжевый; DKC_Классификационный код по ГОСТ Р МЭК 61386.1-2014: 2141 (легкая серия); 3241 (тяжелая серия); DKC_Кол-во в бухте L_м: д.16=100 / д.20=100 / д.25=50 / д.32=25 / д.40=20 / д.50=15; DKC_Минимальный радиус изгиба (количество диаметров): 3; DKC_Прочность (сопротивление сжатию при 20 °С): свыше 125 H на 5 см (легкая серия)*; свыше 320 Н на 5 см (тяжелая серия)*; DKC_Разрывная прочность: не менее 200 Н; DKC_Серия труб: Тяжелая; DKC_Температура монтажа: от –40 до + 90 °С; DKC_Температура эксплуатации: от –40 до + 90 °С; DKC_Ударная прочность при –25 °С: при -40 °С не менее 2 Дж – легкая серия; не менее 6 Дж – тяжелая серия; Тип трубопровода: 70516
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм тяжелая без протяжки 15-100м цвет оранжевый; Комментарии к типоразмеру: Гофрированная труба из ПНД (серия 7)
Name (Короб без соединительных деталей:КНС_Труба ПНД гибкая гофр._DKC_д.16-50мм тяжелая без протяжки 15-100м цвет оранжевый:...) | Внешний диаметр (mm) | Внутренний диаметр (mm) | Диаметр (Размер по каталогу) (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
697545 | 15.7 | 11.3 | 16 | 1994.37 | 16 ммø | 7.85 | -7.85
697551 | 15.7 | 11.3 | 16 | 614.371 | 16 ммø | 7.85 | -7.85
697581 | 19.5 | 14.5 | 20 | 1993.54 | 20 ммø | 9.75 | -9.75
697587 | 19.5 | 14.5 | 20 | 613.543 | 20 ммø | 9.75 | -9.75 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
697618 | 25 | 19 | 25 | 1992.51 | 25 ммø | 12.5 | -12.5
697624 | 25 | 19 | 25 | 612.507 | 25 ммø | 12.5 | -12.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
697652 | 31.1 | 24.3 | 32 | 1991.06 | 32 ммø | 15.55 | -15.55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
697658 | 31.1 | 24.3 | 32 | 611.057 | 32 ммø | 15.55 | -15.55
697686 | 38.7 | 30.7 | 40 | 1989.4 | 40 ммø | 19.35 | -19.35 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
697692 | 38.7 | 30.7 | 40 | 609.401 | 40 ммø | 19.35 | -19.35
697720 | 48.5 | 38.9 | 50 | 1987.33 | 50 ммø | 24.25 | -24.25 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
697726 | 48.5 | 38.9 | 50 | 607.33 | 50 ммø | 24.25 | -24.25 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
