Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T19:58:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 19:58:18 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{00034ED9-BDF5-4AA1-8009-01A94DF8F8A3}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 19:58:18 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 19:58:18 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 19:58:18 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes; Имя типа: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300 (2)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.110мм
300 | Муфта разъемная

# IfcFlowFitting: Муфта разъемная соединительная с фиксатором, КНС_МуфтаРазъемнаяСФиксаторомДляДвустенных-ДренажныхТруб_DKC_д.110:Муфта разъемная соединительная с фиксатором:544934
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен, термопластичная резина
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Материал: DKC_Пластик_Полипропилен, термопластичная резина; DKC_Степень защиты: IP 67; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/84/017110/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Муфта разъемная соединительная с фиксатором; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: механическое разъемное соединение гибких, жестких, дренажных гофрированных двустенных труб одного диаметра, ремонтный комплект для кабельной канализации.
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_МуфтаРазъемнаяСФиксаторомДляДвустенных-ДренажныхТруб_DKC_д.110
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Муфта разъемная соединительная с фиксатором
Графика - Использовать масштаб аннотаций: no
Данные - ADSK_Код изделия: 017110; ADSK_Наименование: Муфта разъемная с фиксатором для двустенных дренажных труб 110мм; ADSK_Наименование краткое: Муфта разъемная с фиксатором для двустенных дренажных труб 110мм
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Прочее - Код типа: КНС_МуфтаРазъемнаяСФиксаторомДляДвустенных-ДренажныхТруб_DKC_д.110: Муфта разъемная соединительная с фиксатором; Семейство: КНС_МуфтаРазъемнаяСФиксаторомДляДвустенных-ДренажныхТруб_DKC_д.110: Муфта разъемная соединительная с фиксатором; Семейство и типоразмер: КНС_МуфтаРазъемнаяСФиксаторомДляДвустенных-ДренажныхТруб_DKC_д.110: Муфта разъемная соединительная с фиксатором; Тип: КНС_МуфтаРазъемнаяСФиксаторомДляДвустенных-ДренажныхТруб_DKC_д.110: Муфта разъемная соединительная с фиксатором
Размеры - D2: 125 mm; DN: 110 mm; L: 196.6 mm; Объем: 0.00241178 m3; Размер: 110 ммøx110 ммø
Стадии - Стадия возведения: Стадия 1
Текст - ADSK_Масса: 0.364
