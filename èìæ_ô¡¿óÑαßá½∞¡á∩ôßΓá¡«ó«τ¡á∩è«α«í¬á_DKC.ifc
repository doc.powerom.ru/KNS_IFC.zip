Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:06:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:06:12 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{94AF4EED-E87C-4240-9E88-C5CC1EC258DF}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:06:11 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:06:11 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:06:11 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcBuildingElementProxy: Текст модели:300 (3)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | 90х71x74
300 | 90х71х110
300 | Универсальная установочная коробка для заливки в бетон

# IfcFlowFitting: 90х71x110мм, КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x110мм:90х71x110мм:715697
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Синий, DKC_Пластик_Полипропилен_Красный
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59393U; ADSK_Материал: DKC_Пластик_Полипропилен_Красный; ADSK_Наименование: Универсальная установочная коробка для заливки в бетон, 90х71x110мм; ADSK_Примечание: универсальная установочная коробка для заливки в бетон; 90х71; h110; DKC_Температура эксплуатации: от –25 до +100 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59393U/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 90х71x110мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: применяется для монтажа скрытой электропроводки, обеспечивая защиту соединенных жил кабелей от внешних воздействий
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x110мм
Type - Размеры - ADSK_Размер_Длина: 110 mm; DN: 20 mm; DN2: 25 mm
Type - Текст - ADSK_Масса: 0.05
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 90х71x110мм
Видимость - Видимость крышки: yes
Данные - ADSK_Наименование краткое: Универсальная установочная коробка для заливки в бетон, 90х71x110мм
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x110мм: 90х71x110мм; Семейство: КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x110мм: 90х71x110мм; Семейство и типоразмер: КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x110мм: 90х71x110мм; Тип: КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x110мм: 90х71x110мм
Размеры - Объем: 0.00046768 m3; Площадь: 0.0344598 m2; Размер: 25 ммøx25 ммøx25 ммøx25 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммøx20 ммø
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 90х71x74мм, КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x74мм:90х71x74мм:715698
In: Этаж 01
Type - Material: DKC_Пластик_Полипропилен_Синий, DKC_Пластик_Полипропилен_Красный
Type - Данные - ADSK_Материал: DKC_Пластик_Полипропилен_Красный; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59392U; ADSK_Наименование: Универсальная установочная коробка для заливки в бетон, 90х71x74мм; ADSK_Примечание: универсальная установочная коробка для заливки в бетон; 90х71; h74; DKC_Температура эксплуатации: от –25 до +100 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59392U/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 90х71x74мм; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: применяется для монтажа скрытой электропроводки, обеспечивая защиту соединенных жил кабелей от внешних воздействий
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x74мм
Type - Размеры - ADSK_Размер_Длина: 74 mm; DN: 20 mm; DN2: 25 mm
Type - Текст - ADSK_Масса: 0.05
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 90х71x74мм
Видимость - Видимость крышки: yes
Данные - ADSK_Наименование краткое: Универсальная установочная коробка для заливки в бетон, 90х71x74мм
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x74мм: 90х71x74мм; Семейство: КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x74мм: 90х71x74мм; Семейство и типоразмер: КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x74мм: 90х71x74мм; Тип: КНС_УниверсальнаяУстановочнаяКоробка_DKC_90х71x74мм: 90х71x74мм
Размеры - Объем: 0.00033548 m3; Площадь: 0.026821 m2; Размер: 25 ммøx25 ммøx20 ммøx20 ммøx20 ммøx20 ммø
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: Крышка для коробки установочной (2)
In: Этаж 01
Type - Material: DKC_Пластик_Полистирол_Белый
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59386; ADSK_Материал: DKC_Пластик_Полистирол_Белый; ADSK_Наименование: Крышка для коробки установочной, IP40, д.87мм; ADSK_Наименование краткое: Крышка для коробки установочной, IP40, д.87мм; DKC_Степень защиты: IP 40
Type - Зависимости - Отметка по умолчанию: 1219.2 mm
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59386/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: Крышка для коробки установочной; Номер OmniClass: 23.80.30.17.11; Описание: использование коробки установочной в качестве распаечной
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КрышкаДляКоробкиУстановочной_DKC
Type - Текст - ADSK_Масса: 0.016
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Крышка для коробки установочной
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no
Прочее - Код типа: КНС_КрышкаДляКоробкиУстановочной_DKC: Крышка для коробки установочной; Семейство: КНС_КрышкаДляКоробкиУстановочной_DKC: Крышка для коробки установочной; Семейство и типоразмер: КНС_КрышкаДляКоробкиУстановочной_DKC: Крышка для коробки установочной; Тип: КНС_КрышкаДляКоробкиУстановочной_DKC: Крышка для коробки установочной
Размеры - Объем: 0.000029722 m3; Площадь: 0.00662718 m2
Стадии - Стадия возведения: Стадия 1
Name (КНС_КрышкаДляКоробкиУстановочной_DKC:Крышка для коробки установочной:...)
715707
796492 | Идентификация - Вариант конструкции: Главная модель
