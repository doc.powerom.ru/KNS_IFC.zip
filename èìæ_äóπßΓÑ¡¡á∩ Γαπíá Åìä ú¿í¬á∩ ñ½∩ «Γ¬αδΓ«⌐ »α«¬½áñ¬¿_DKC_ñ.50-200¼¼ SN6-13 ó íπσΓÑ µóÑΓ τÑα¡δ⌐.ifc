Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T16:04:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 16:04:09 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{703EFAAB-EF03-4F3C-A6B0-9D02F4A12DED}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 16:04:04 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 16:04:05 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 16:04:05 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (10)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
300 | д.50мм | Лого : Лого
300 | д.63мм | Лого : Лого
300 | д.75мм | Лого (основной)
300 | д.90мм | Лого (основной)
300 | д.110мм | Лого : Лого
300 | д.125мм | Лого (основной)
300 | д.140мм | Лого : Лого
300 | д.160мм | Лого : Лого
300 | д.200мм | Лого (основной)
300 | Двустенная труба ПНД гибкая для открытой прокладки, д.50-200мм, SN6-13, в бухте 35-100м, цвет черный | Лого (основной)

# IfcDistributionPort (32)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_564225
2 x OutPort_564227
InPort_564226
InPort_564229
2 x OutPort_564231
InPort_564230
InPort_564233
2 x OutPort_564235
InPort_564234
InPort_564237
2 x OutPort_564239
InPort_564238
InPort_564241
2 x OutPort_564243
InPort_564242
InPort_564245
2 x OutPort_564247
InPort_564246
InPort_564249
2 x OutPort_564251
InPort_564250
InPort_564253
2 x OutPort_564255
InPort_564254

# IfcFlowFitting: Неспецифицируемый_черный (8)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Черный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Черный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_черный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_черный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Размеры - Длина короба: 1 mm; Радиус загиба: 10 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_черный:...) | Вариант конструкции | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
564227 | Главная модель | 34.675 | 63 | 31.5 | 0.0000911247 | 15.3629 | 63 ммøx63 ммø
564231 | Главная модель | 40.675 | 75 | 37.5 | 0.000149963 | 17.8481 | 75 ммøx75 ммø
564235 |  | 48.175 | 90 | 45 | 0.000253418 | 20.9547 | 90 ммøx90 ммø
564239 | Главная модель | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø
564243 | Главная модель | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø
564247 | Главная модель | 73.175 | 140 | 70 | 0.000915454 | 31.3101 | 140 ммøx140 ммø
564251 | Главная модель | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø
564255 | Главная модель | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для открытой прокладки_DKC_д.50-200мм SN6-13 в бухте цвет черный (18)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для открытой прокладки_DKC_д.50-200мм SN6-13 в бухте цвет черный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для открытой прокладки_DKC_д.50-200мм SN6-13 в бухте цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для открытой прокладки_DKC_д.50-200мм SN6-13 в бухте цвет черный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для открытой прокладки_DKC_д.50-200мм SN6-13 в бухте цвет черный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая для открытой прокладки
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД гибкая для открытой прокладки_DKC_д.50-200мм SN6-13 в бухте цвет черный
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/61/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД гибкая для открытой прокладки_DKC_д.50-200мм SN6-13 в бухте цвет черный; Комментарии к типоразмеру: Гибкие двустенные гофрированные трубы для открытой прокладки
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-047-47022248-2015; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Наименование: Двустенная труба ПНД гибкая для открытой прокладки, д.50-200мм, SN6-13, в бухте, цвет черный; ADSK_Наименование краткое: Двустенная труба ПНД гибкая для открытой прокладки, д.50-200мм, SN6-13, в бухте, цвет черный; DKC_Климатическое исполнение: У1 по ГОСТ 15150-69; DKC_Кол-во в бухте L_м: д.50 SN13=100 / д.63 SN13=50 / д.75 SN10=50 / д.90 SN8=50 / д.110 SN8=50 / д.125 SN8=40 / д.140 SN6=50 / д.160 SN6=50 / д.200 SN6=35; DKC_Кольцевая жесткость_кПа: д.50 SN13=13 / д.63 SN13=13 / д.75 SN10=10 / д.90 SN8=8 / д.110 SN8=8 / д.125 SN8=8 / д.140 SN6=6 / д.160 SN6=6 / д.200 SN6=6; DKC_Минимальный радиус изгиба (количество диаметров): 8; DKC_Соответствие требованиям пожарной безопасности: Соответствует ГОСТ Р 53313; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Стойкость к ультрафиолету: В соответствии с ГОСТ Р 20.57.406 метод 211-1; DKC_Температура монтажа: от –25 до + 90 °С; DKC_Температура эксплуатации: от –55 до + 90 °С; DKC_Условия монтажа: Для открытой прокладки электропроводки и кабельных линий в кабельных сооружениях и наружных электроустановках: мосты, путепроводы, эстакады, галереи, в местах выходов из земли и вводе в здание; Тип трубопровода: 1519
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для открытой прокладки_DKC_д.50-200мм SN6-13 в бухте цвет черный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm) | Вариант конструкции | sets with these values
564221 | 50 | 41.5 | 1987.33 | 50 ммø | 25 | -25
564222 | 50 | 41.5 | 987.33 | 50 ммø | 25 | -25 | Главная модель | 2
564225 | 63 | 51.5 | 1984.64 | 63 ммø | 31.5 | -31.5 | Главная модель | 2
564226 | 63 | 51.5 | 984.637 | 63 ммø | 31.5 | -31.5 | Главная модель | 2
564229 | 75 | 62.5 | 1982.15 | 75 ммø | 37.5 | -37.5
564230 | 75 | 62.5 | 982.152 | 75 ммø | 37.5 | -37.5 | Главная модель | 2
564233 | 90 | 77 | 1979.05 | 90 ммø | 45 | -45
564234 | 90 | 77 | 979.045 | 90 ммø | 45 | -45 | Главная модель | 2
564237 | 110 | 94 | 1974.9 | 110 ммø | 55 | -55 | Главная модель | 2
564238 | 110 | 94 | 974.903 | 110 ммø | 55 | -55 | Главная модель | 2
564241 | 125 | 107 | 1971.8 | 125 ммø | 62.5 | -62.5 | Главная модель | 2
564242 | 125 | 107 | 971.797 | 125 ммø | 62.5 | -62.5 | Главная модель | 2
564245 | 140 | 120 | 1968.69 | 140 ммø | 70 | -70
564246 | 140 | 120 | 968.69 | 140 ммø | 70 | -70
564249 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80 | Главная модель | 2
564250 | 160 | 137 | 964.548 | 160 ммø | 80 | -80
564253 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
564254 | 200 | 172 | 956.264 | 200 ммø | 100 | -100
