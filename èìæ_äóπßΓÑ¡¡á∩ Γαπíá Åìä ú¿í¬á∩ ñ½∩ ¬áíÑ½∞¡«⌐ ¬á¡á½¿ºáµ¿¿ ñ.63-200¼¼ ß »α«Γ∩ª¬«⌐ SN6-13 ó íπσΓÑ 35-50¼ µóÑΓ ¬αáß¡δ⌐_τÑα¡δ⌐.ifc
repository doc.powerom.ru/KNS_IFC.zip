Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T17:04:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 17:04:42 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{A8C4F6F3-BF10-4E20-95DE-18DBDC61D59E}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 17:04:40 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 17:04:40 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 17:04:40 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (9)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | д.63мм
300 | д.75мм
300 | д.90мм
300 | д.110мм
300 | д.125мм
300 | д.140мм
300 | д.160мм
300 | д.200мм | Идентификация - Вариант конструкции: Главная модель
300 | Двустенная труба ПНД гибкая для кабельной канализации, д.63-200мм с протяжкой, SN6-13, в бухте 35-50м, цвет красный/черный | Идентификация - Вариант конструкции: Главная модель

# IfcDistributionPort (64)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
InPort_638927
2 x OutPort_638929
InPort_638928
InPort_638931
2 x OutPort_638933
InPort_638932
InPort_638935
2 x OutPort_638937
InPort_638936
InPort_638939
2 x OutPort_638941
InPort_638940
InPort_638943
2 x OutPort_638945
InPort_638944
InPort_638947
2 x OutPort_638949
InPort_638948
InPort_638951
2 x OutPort_638953
InPort_638952
InPort_638955
2 x OutPort_638957
InPort_638956
InPort_640106
2 x OutPort_640108
InPort_640107
InPort_640110
2 x OutPort_640112
InPort_640111
InPort_640114
2 x OutPort_640116
InPort_640115
InPort_640118
2 x OutPort_640120
InPort_640119
InPort_640122
2 x OutPort_640124
InPort_640123
InPort_640126
2 x OutPort_640128
InPort_640127
InPort_640130
2 x OutPort_640132
InPort_640131
InPort_640134
2 x OutPort_640136
InPort_640135

# IfcFlowFitting: Неспецифицируемый_красный (8)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Красный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Красный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_красный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_красный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный
Размеры - Длина короба: 1 mm; Радиус загиба: 10 mm; Угол: 45 deg
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_красный:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер | Вариант конструкции
638929 | 34.675 | 63 | 31.5 | 0.0000911247 | 15.3629 | 63 ммøx63 ммø
638933 | 40.675 | 75 | 37.5 | 0.000149963 | 17.8481 | 75 ммøx75 ммø | Главная модель
638937 | 48.175 | 90 | 45 | 0.000253418 | 20.9547 | 90 ммøx90 ммø | Главная модель
638941 | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø | Главная модель
638945 | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø | Главная модель
638949 | 73.175 | 140 | 70 | 0.000915454 | 31.3101 | 140 ммøx140 ммø | Главная модель
638953 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø | Главная модель
638957 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø | Главная модель

# IfcFlowFitting: Неспецифицируемый_черный (8)
In: Этаж 01
Type - Material: DKC_Неспецифицируемый_Черный
Type - Данные - ADSK_Материал: DKC_Неспецифицируемый_Черный; ADSK_Наименование: Неспецифицируемый
Type - Идентификация - Заголовок OmniClass: Conduits; Имя типа: Неспецифицируемый_черный; Номер OmniClass: 23.80.30.17.11
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_ОтводДляКоробаНеспецифицируемый_DKC
Pset_DistributionFlowElementCommon - Reference: Неспецифицируемый_черный
Графика - Использовать масштаб аннотаций: no
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Изгиб или соединительная деталь: Изгиб; Код типа: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Семейство и типоразмер: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный; Тип: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_черный
Размеры - Угол: 45 deg; Длина короба: 1 mm; Радиус загиба: 10 mm
Стадии - Стадия возведения: Стадия 1
Name (КНС_ОтводДляКоробаНеспецифицируемый_DKC:Неспецифицируемый_черный:...) | Метка радиуса загиба (mm) | Наружный диаметр фитинга (mm) = Номинальный диаметр (mm) | Наружный радиус фитинга (mm) = Номинальный радиус (mm) | Объем (m3) | От центра до конца (mm) | Размер
640108 | 34.675 | 63 | 31.5 | 0.0000911247 | 15.3629 | 63 ммøx63 ммø
640112 | 40.675 | 75 | 37.5 | 0.000149963 | 17.8481 | 75 ммøx75 ммø
640116 | 48.175 | 90 | 45 | 0.000253418 | 20.9547 | 90 ммøx90 ммø
640120 | 58.175 | 110 | 55 | 0.000453199 | 25.0969 | 110 ммøx110 ммø
640124 | 65.675 | 125 | 62.5 | 0.00065751 | 28.2035 | 125 ммøx125 ммø
640128 | 73.175 | 140 | 70 | 0.000915454 | 31.3101 | 140 ммøx140 ммø
640132 | 83.175 | 160 | 80 | 0.0013536 | 35.4522 | 160 ммøx160 ммø
640136 | 103.175 | 200 | 100 | 0.00260846 | 43.7365 | 200 ммøx200 ммø

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет красный (16)
In: Этаж 01
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Прочее - Категория: Короба; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет красный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет красный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет красный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет красный; sets with these values: 2; Имя семейства: Короб без соединительных деталей
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Электросети - sets with these values: 2; Стандартное: Стандартные типы коробов: ПНД гибкая для кабельной канализации в бухте 35-50м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет красный
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/88/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет красный; Комментарии к типоразмеру: Гибкие двустенные гофрированные трубы (красные/черные (А))
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-015-47022248-2006; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Красный; ADSK_Наименование: Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой, SN6-13, в бухте 35-50м, цвет красный; ADSK_Наименование краткое: Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой, SN6-13, в бухте 35-50м, цвет красный; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кол-во в бухте L_м: д.63 SN13=50 / д.75 SN10=50 / д.90 SN8=50 / д.110 SN8=50 / д.125 SN8=40 / д.140 SN6=50 / д.160 SN6=50 / д.200 SN6=35; DKC_Кольцевая жесткость_кПа: д.63 SN13=13 / д.75 SN10=10 / д.90 SN8=8 / д.110 SN8=8 / д.125 SN8=8 / д.140 SN6=6 / д.160 SN6=6 / д.200 SN6=6; DKC_Минимальный радиус изгиба (количество диаметров): 8; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –25 до + 90 °С; DKC_Температура эксплуатации: от –55 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или при монолитном бетоностроении); Тип трубопровода: 121951
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет красный:...) | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
638927 | 63 | 51.5 | 1984.64 | 63 ммø | 31.5 | -31.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638928 | 63 | 51.5 | 984.637 | 63 ммø | 31.5 | -31.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638931 | 75 | 62.5 | 1982.15 | 75 ммø | 37.5 | -37.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638932 | 75 | 62.5 | 982.152 | 75 ммø | 37.5 | -37.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638935 | 90 | 77 | 1979.05 | 90 ммø | 45 | -45
638936 | 90 | 77 | 979.045 | 90 ммø | 45 | -45
638939 | 110 | 94 | 1974.9 | 110 ммø | 55 | -55
638940 | 110 | 94 | 974.903 | 110 ммø | 55 | -55 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638943 | 125 | 107 | 1971.8 | 125 ммø | 62.5 | -62.5
638944 | 125 | 107 | 971.797 | 125 ммø | 62.5 | -62.5 | Идентификация - Вариант конструкции: Главная модель; sets with these values: 2
638947 | 140 | 120 | 1968.69 | 140 ммø | 70 | -70
638948 | 140 | 120 | 968.69 | 140 ммø | 70 | -70
638951 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80
638952 | 160 | 137 | 964.548 | 160 ммø | 80 | -80
638955 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
638956 | 200 | 172 | 956.264 | 200 ммø | 100 | -100

# IfcFlowSegment: Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет черный (16)
In: Этаж 01
Электросети - Стандартное: Стандартные типы коробов: ПНД гибкая для кабельной канализации в бухте 35-50м; sets with these values: 2
Соединительные детали - Изгиб: КНС_ОтводДляКоробаНеспецифицируемый_DKC: Неспецифицируемый_красный; Пересечение: КНС_КрестообразноеСоединениеДляДвустенныхТруб_DKC_д.63-200: Крестовина; Переходный: КНС_ПереходникДляДвустенныхТруб_DKC_д.90-200: Переходник; Соединение: КНС_МуфтаДляДвустенных-ДренажныхТруб_DKC_д.50-200: Муфта соединительная; Тройник: КНС_ТройникДляДвустенныхТруб_DKC_д.63-200: Тройник
Прочее - Категория: Короба; Имя семейства: Короб без соединительных деталей; Код типа: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет черный; Семейство: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет черный; Семейство и типоразмер: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет черный; Тип: Короб без соединительных деталей: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет черный; sets with these values: 2
Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/88/; ADSK_Версия Revit: 2017; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Изготовитель: DKC; Имя типа: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет черный; Комментарии к типоразмеру: Гибкие двустенные гофрированные трубы (красные/черные (А))
Зависимости - Базовый уровень: Уровень: Этаж 01; Выравнивание по вертикали: Середина; Выравнивание по горизонтали: Центр; Смещение: 0 mm; Смещение в конце: 0 mm; Смещение в начале: 0 mm; sets with these values: 2
Размеры - sets with these values: 2
Стадии - Стадия возведения: Стадия 1; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет черный
Данные - ADSK_Единица измерения: м; ADSK_Завод-изготовитель: DKC; ADSK_Марка: ТУ 2248-015-47022248-2006; ADSK_Материал: DKC_ПНД (полиэтилен низкого давления)_Черный; ADSK_Наименование: Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой, SN6-13, в бухте 35-50м, цвет черный; ADSK_Наименование краткое: Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой, SN6-13, в бухте 35-50м, цвет черный; DKC_Климатическое исполнение: Для прокладки в невоздушной среде (грунт, бетон) по ГОСТ 15150-69; DKC_Кол-во в бухте L_м: д.63 SN13=50 / д.75 SN10=50 / д.90 SN8=50 / д.110 SN8=50 / д.125 SN8=40 / д.140 SN6=50 / д.160 SN6=50 / д.200 SN6=35; DKC_Кольцевая жесткость_кПа: д.63 SN13=13 / д.75 SN10=10 / д.90 SN8=8 / д.110 SN8=8 / д.125 SN8=8 / д.140 SN6=6 / д.160 SN6=6 / д.200 SN6=6; DKC_Минимальный радиус изгиба (количество диаметров): 8; DKC_Степень защиты: IP 44/55/67 по ГОСТ 14254-96; DKC_Температура монтажа: от –25 до + 90 °С; DKC_Температура эксплуатации: от –55 до + 90 °С; DKC_Условия монтажа: Допускаются только скрытые виды монтажа (в грунте или при монолитном бетоностроении); Тип трубопровода: 121953
Name (Короб без соединительных деталей:КНС_Двустенная труба ПНД гибкая для кабельной канализации д.63-200мм с протяжкой SN6-13 в бухте 35-50м цвет черный:...) | Вариант конструкции | sets with these values | Внешний диаметр (mm) = Диаметр (Размер по каталогу) (mm) | Внутренний диаметр (mm) | Длина (mm) | Размер | Верхняя отметка (mm) | Нижняя отметка (mm)
640106 | Главная модель | 2 | 63 | 51.5 | 1984.64 | 63 ммø | 31.5 | -31.5
640107 |  |  | 63 | 51.5 | 984.637 | 63 ммø | 31.5 | -31.5
640110 |  |  | 75 | 62.5 | 1982.15 | 75 ммø | 37.5 | -37.5
640111 | Главная модель | 2 | 75 | 62.5 | 982.152 | 75 ммø | 37.5 | -37.5
640114 | Главная модель | 2 | 90 | 77 | 1979.05 | 90 ммø | 45 | -45
640115 | Главная модель | 2 | 90 | 77 | 979.045 | 90 ммø | 45 | -45
640118 | Главная модель | 2 | 110 | 94 | 1974.9 | 110 ммø | 55 | -55
640119 | Главная модель | 2 | 110 | 94 | 974.903 | 110 ммø | 55 | -55
640122 | Главная модель | 2 | 125 | 107 | 1971.8 | 125 ммø | 62.5 | -62.5
640123 |  |  | 125 | 107 | 971.797 | 125 ммø | 62.5 | -62.5
640126 | Главная модель | 2 | 140 | 120 | 1968.69 | 140 ммø | 70 | -70
640127 |  |  | 140 | 120 | 968.69 | 140 ммø | 70 | -70
640130 | Главная модель | 2 | 160 | 137 | 1964.55 | 160 ммø | 80 | -80
640131 |  |  | 160 | 137 | 964.548 | 160 ммø | 80 | -80
640134 | Главная модель | 2 | 200 | 172 | 1956.26 | 200 ммø | 100 | -100
640135 | Главная модель | 2 | 200 | 172 | 956.264 | 200 ммø | 100 | -100
