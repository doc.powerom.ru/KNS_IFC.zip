Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-14T20:05:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Альтернативный интерфейс 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 14 20:05:31 2020 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{0575C2CF-D86B-46B9-BFF0-D598CCCAD1FC}\ifc * Database version: 5507 * Database creation date: Mon Sep 14 20:05:30 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 14 20:05:30 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 14 20:05:30 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Идентификация - Имя типа: Отметка уровня с именем; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Зависимости - Базовая отметка: Базовая точка проекта; Фасад: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: Текст модели:300 (10)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 300
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели; Имя типа: 300
Материалы и отделка - Материал: BIMLIB_СерыйЛого_DKC
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 300; Семейство: Текст модели: 300; Семейство и типоразмер: Текст модели: 300; Тип: Текст модели: 300; Имя семейства: Текст модели
Размеры - Глубина:: 20 mm
Стадии - Стадия возведения: Стадия 1
Текст - Жирный: no; Курсив: no; Размер текста: 300 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
300 | 92х92х45 | Идентификация - Вариант конструкции: Главная модель
300 | 118х96х50 | Идентификация - Вариант конструкции: Главная модель
300 | 118х96х70 | Идентификация - Вариант конструкции: Главная модель
300 | 154х98х70
300 | 160х130х70 | Идентификация - Вариант конструкции: Главная модель
300 | 196х152х70
300 | Коробка ответвительная прямоуг. для твердых стен, IP40 | Идентификация - Вариант конструкции: Главная модель
300 | 297х152х70
300 | 392х152х70
300 | 480х160х70

# IfcFlowFitting: 118х96х50, КНС_КоробкаОтветвительнаяПрямоугольная_DKC:118х96х50:702140
In: Этаж 01
Type - Material: DKC_Пластик_Полистирол_Оранжевый
Type - Данные - ADSK_Материал: DKC_Пластик_Полистирол_Оранжевый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59362; ADSK_Наименование: Коробка ответвительная прямоуг. для твердых стен, IP40, 118х96х50мм; ADSK_Наименование краткое: Коробка ответвительная прямоуг. для твердых стен, IP40, 118х96х50мм; DKC_Степень защиты: IP 40; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59362/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 118х96х50; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: декоративное оформление и защита мест соединения силовых и информационных кабелей; предназначена для скрытой установки в негорючих основаниях
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаОтветвительнаяПрямоугольная_DKC
Type - Размеры - ADSK_Размер_Высота: 50 mm; ADSK_Размер_Длина: 118 mm; ADSK_Размер_Ширина: 96 mm
Type - Текст - ADSK_Масса: 0.08
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 118х96х50
Видимость - Видимость крышки: yes
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 118х96х50; Семейство: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 118х96х50; Семейство и типоразмер: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 118х96х50; Тип: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 118х96х50
Размеры - Объем: 0.000217416 m3; Площадь: 0.036724 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 118х96х70, КНС_КоробкаОтветвительнаяПрямоугольная_DKC:118х96х70:702132
In: Этаж 01
Type - Material: DKC_Пластик_Полистирол_Оранжевый
Type - Данные - ADSK_Материал: DKC_Пластик_Полистирол_Оранжевый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59363; ADSK_Наименование: Коробка ответвительная прямоуг. для твердых стен, IP40, 118х96х70мм; ADSK_Наименование краткое: Коробка ответвительная прямоуг. для твердых стен, IP40, 118х96х70мм; DKC_Степень защиты: IP 40; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59363/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 118х96х70; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: декоративное оформление и защита мест соединения силовых и информационных кабелей; предназначена для скрытой установки в негорючих основаниях
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаОтветвительнаяПрямоугольная_DKC
Type - Размеры - ADSK_Размер_Высота: 70 mm; ADSK_Размер_Длина: 118 mm; ADSK_Размер_Ширина: 96 mm
Type - Текст - ADSK_Масса: 0.09
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 118х96х70
Видимость - Видимость крышки: yes
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 118х96х70; Семейство: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 118х96х70; Семейство и типоразмер: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 118х96х70; Тип: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 118х96х70
Размеры - Объем: 0.000267816 m3; Площадь: 0.043924 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 154х98х70, КНС_КоробкаОтветвительнаяПрямоугольная_DKC:154х98х70:702124
In: Этаж 01
Type - Material: DKC_Пластик_Полистирол_Оранжевый
Type - Данные - ADSK_Материал: DKC_Пластик_Полистирол_Оранжевый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59364; ADSK_Наименование: Коробка ответвительная прямоуг. для твердых стен, IP40, 154х98х70мм; ADSK_Наименование краткое: Коробка ответвительная прямоуг. для твердых стен, IP40, 154х98х70мм; DKC_Степень защиты: IP 40; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59364/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 154х98х70; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: декоративное оформление и защита мест соединения силовых и информационных кабелей; предназначена для скрытой установки в негорючих основаниях
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаОтветвительнаяПрямоугольная_DKC
Type - Размеры - ADSK_Размер_Высота: 70 mm; ADSK_Размер_Длина: 154 mm; ADSK_Размер_Ширина: 98 mm
Type - Текст - ADSK_Масса: 0.11
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 154х98х70
Видимость - Видимость крышки: yes
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 154х98х70; Семейство: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 154х98х70; Семейство и типоразмер: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 154х98х70; Тип: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 154х98х70
Размеры - Объем: 0.00034118 m3; Площадь: 0.055936 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 160х130х70, КНС_КоробкаОтветвительнаяПрямоугольная_DKC:160х130х70:702116
In: Этаж 01
Type - Material: DKC_Пластик_Полистирол_Оранжевый
Type - Данные - ADSK_Материал: DKC_Пластик_Полистирол_Оранжевый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59365; ADSK_Наименование: Коробка ответвительная прямоуг. для твердых стен, IP40, 160х130х70мм; ADSK_Наименование краткое: Коробка ответвительная прямоуг. для твердых стен, IP40, 160х130х70мм; DKC_Степень защиты: IP 40; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59365/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 160х130х70; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: декоративное оформление и защита мест соединения силовых и информационных кабелей; предназначена для скрытой установки в негорючих основаниях
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаОтветвительнаяПрямоугольная_DKC
Type - Размеры - ADSK_Размер_Высота: 70 mm; ADSK_Размер_Длина: 160 mm; ADSK_Размер_Ширина: 130 mm
Type - Текст - ADSK_Масса: 0.148
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 160х130х70
Видимость - Видимость крышки: yes
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 160х130х70; Семейство: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 160х130х70; Семейство и типоразмер: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 160х130х70; Тип: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 160х130х70
Размеры - Объем: 0.000437872 m3; Площадь: 0.071836 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 196х152х70, КНС_КоробкаОтветвительнаяПрямоугольная_DKC:196х152х70:702108
In: Этаж 01
Type - Material: DKC_Пластик_Полистирол_Оранжевый
Type - Данные - ADSK_Материал: DKC_Пластик_Полистирол_Оранжевый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59366; ADSK_Наименование: Коробка ответвительная прямоуг. для твердых стен, IP40, 196х152х70мм; ADSK_Наименование краткое: Коробка ответвительная прямоуг. для твердых стен, IP40, 196х152х70мм; DKC_Степень защиты: IP 40; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59366/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 196х152х70; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: декоративное оформление и защита мест соединения силовых и информационных кабелей; предназначена для скрытой установки в негорючих основаниях
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаОтветвительнаяПрямоугольная_DKC
Type - Размеры - ADSK_Размер_Высота: 70 mm; ADSK_Размер_Длина: 196 mm; ADSK_Размер_Ширина: 152 mm
Type - Текст - ADSK_Масса: 0.22
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 196х152х70
Видимость - Видимость крышки: yes
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 196х152х70; Семейство: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 196х152х70; Семейство и типоразмер: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 196х152х70; Тип: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 196х152х70
Размеры - Объем: 0.000588812 m3; Площадь: 0.096664 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 297х152х70, КНС_КоробкаОтветвительнаяПрямоугольная_DKC:297х152х70:702100
In: Этаж 01
Type - Material: DKC_Пластик_Полистирол_Оранжевый
Type - Данные - ADSK_Материал: DKC_Пластик_Полистирол_Оранжевый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59367; ADSK_Наименование: Коробка ответвительная прямоуг. для твердых стен, IP40, 297х152х70мм; ADSK_Наименование краткое: Коробка ответвительная прямоуг. для твердых стен, IP40, 297х152х70мм; DKC_Степень защиты: IP 40; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59367/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 297х152х70; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: декоративное оформление и защита мест соединения силовых и информационных кабелей; предназначена для скрытой установки в негорючих основаниях
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаОтветвительнаяПрямоугольная_DKC
Type - Размеры - ADSK_Размер_Высота: 70 mm; ADSK_Размер_Длина: 297 mm; ADSK_Размер_Ширина: 152 mm
Type - Текст - ADSK_Масса: 0.31
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 297х152х70
Видимость - Видимость крышки: yes
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Прочее - Код типа: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 297х152х70; Семейство: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 297х152х70; Семейство и типоразмер: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 297х152х70; Тип: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 297х152х70
Размеры - Объем: 0.000847978 m3; Площадь: 0.139286 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 392х152х70, КНС_КоробкаОтветвительнаяПрямоугольная_DKC:392х152х70:702092
In: Этаж 01
Type - Material: DKC_Пластик_Полистирол_Оранжевый
Type - Данные - ADSK_Материал: DKC_Пластик_Полистирол_Оранжевый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59368; ADSK_Наименование: Коробка ответвительная прямоуг. для твердых стен, IP40, 392х152х70мм; ADSK_Наименование краткое: Коробка ответвительная прямоуг. для твердых стен, IP40, 392х152х70мм; DKC_Степень защиты: IP 40; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59368/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 392х152х70; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: декоративное оформление и защита мест соединения силовых и информационных кабелей; предназначена для скрытой установки в негорючих основаниях
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаОтветвительнаяПрямоугольная_DKC
Type - Размеры - ADSK_Размер_Высота: 70 mm; ADSK_Размер_Длина: 392 mm; ADSK_Размер_Ширина: 152 mm
Type - Текст - ADSK_Масса: 0.46
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 392х152х70
Видимость - Видимость крышки: yes
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 392х152х70; Семейство: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 392х152х70; Семейство и типоразмер: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 392х152х70; Тип: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 392х152х70
Размеры - Объем: 0.00109175 m3; Площадь: 0.179376 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 480х160х70, КНС_КоробкаОтветвительнаяПрямоугольная_DKC:480х160х70:702070
In: Этаж 01
Type - Material: DKC_Пластик_Полистирол_Оранжевый
Type - Данные - ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59369; ADSK_Материал: DKC_Пластик_Полистирол_Оранжевый; ADSK_Наименование: Коробка ответвительная прямоуг. для твердых стен, IP40, 480х160х70мм; ADSK_Наименование краткое: Коробка ответвительная прямоуг. для твердых стен, IP40, 480х160х70мм; DKC_Степень защиты: IP 40; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59369/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 480х160х70; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: декоративное оформление и защита мест соединения силовых и информационных кабелей; предназначена для скрытой установки в негорючих основаниях
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаОтветвительнаяПрямоугольная_DKC
Type - Размеры - ADSK_Размер_Высота: 70 mm; ADSK_Размер_Длина: 480 mm; ADSK_Размер_Ширина: 160 mm
Type - Текст - ADSK_Масса: 0.58
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 480х160х70
Видимость - Видимость крышки: yes
Зависимости - Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 480х160х70; Семейство: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 480х160х70; Семейство и типоразмер: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 480х160х70; Тип: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 480х160х70
Размеры - Объем: 0.00136957 m3; Площадь: 0.225136 m2
Стадии - Стадия возведения: Стадия 1

# IfcFlowFitting: 92х92х45, КНС_КоробкаОтветвительнаяПрямоугольная_DKC:92х92х45:702148
In: Этаж 01
Type - Material: DKC_Пластик_Полистирол_Оранжевый
Type - Данные - ADSK_Материал: DKC_Пластик_Полистирол_Оранжевый; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: 59361; ADSK_Наименование: Коробка ответвительная прямоуг. для твердых стен, IP40, 92х92х45мм; ADSK_Наименование краткое: Коробка ответвительная прямоуг. для твердых стен, IP40, 92х92х45мм; DKC_Степень защиты: IP 40; DKC_Температура эксплуатации: от –40 до +90 °С
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/963/59361/; ADSK_Версия Revit: 2017; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; BL_Разработано: support@bimlib.ru; URL: https://www.dkc.ru/; Заголовок OmniClass: Conduits; Изготовитель: DKC; Имя типа: 92х92х45; Номер OmniClass: 23.80.30.17.11; Описание: Назначение: декоративное оформление и защита мест соединения силовых и информационных кабелей; предназначена для скрытой установки в негорючих основаниях
Type - Прочее - Категория: Соединительные детали коробов; Имя семейства: КНС_КоробкаОтветвительнаяПрямоугольная_DKC
Type - Размеры - ADSK_Размер_Высота: 45 mm; ADSK_Размер_Длина: 92 mm; ADSK_Размер_Ширина: 92 mm
Type - Текст - ADSK_Масса: 0.07
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 92х92х45
Видимость - Видимость крышки: yes
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель
Прочее - Код типа: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 92х92х45; Семейство: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 92х92х45; Семейство и типоразмер: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 92х92х45; Тип: КНС_КоробкаОтветвительнаяПрямоугольная_DKC: 92х92х45
Размеры - Объем: 0.000158688 m3; Площадь: 0.027156 m2
Стадии - Стадия возведения: Стадия 1
